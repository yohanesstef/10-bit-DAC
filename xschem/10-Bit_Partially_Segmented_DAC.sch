v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {10b_DAC_top.sym} 470 -340 0 0 {name=x1}
C {devices/lab_pin.sym} 320 -410 0 0 {name=p13 sig_type=std_logic lab=DIN[0..9]}
C {devices/lab_pin.sym} 320 -290 2 1 {name=p1 sig_type=std_logic lab=ROUT1}
C {devices/lab_pin.sym} 320 -350 2 1 {name=p14 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 320 -330 2 1 {name=p5 sig_type=std_logic lab=VDDH}
C {devices/lab_pin.sym} 320 -310 2 1 {name=p6 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 320 -370 2 1 {name=p7 sig_type=std_logic lab=VDDH}
C {devices/lab_pin.sym} 320 -390 2 1 {name=p2 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 320 -270 2 1 {name=p3 sig_type=std_logic lab=ROUT2}
C {devices/lab_pin.sym} 620 -410 2 0 {name=p4 sig_type=std_logic lab=VOUT}
C {devices/opin.sym} 770 -390 0 0 {name=p19 lab=VOUT}
C {devices/ipin.sym} 790 -330 0 0 {name=p20 lab=GND}
C {devices/ipin.sym} 790 -450 0 0 {name=p8 lab=DIN[0..9]}
C {devices/ipin.sym} 790 -370 0 0 {name=p9 lab=VDD}
C {devices/ipin.sym} 790 -350 0 0 {name=p10 lab=VDDH}
C {devices/ipin.sym} 790 -430 0 0 {name=p11 lab=ROUT1}
C {devices/ipin.sym} 790 -410 0 0 {name=p131 lab=ROUT2}
