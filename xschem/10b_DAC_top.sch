** sch_path: xschem/10b_DAC_top.sch
**.subckt 10b_DAC_top VOUT GND DIN[0],DIN[1],DIN[2],DIN[3],DIN[4],DIN[5],DIN[6],DIN[7],DIN[8],DIN[9]
*+ VDD VDDH VDDA GNDA ROUT1
*.opin VOUT
*.ipin GND
*.ipin DIN[0],DIN[1],DIN[2],DIN[3],DIN[4],DIN[5],DIN[6],DIN[7],DIN[8],DIN[9]
*.ipin VDD
*.ipin VDDH
*.ipin VDDA
*.ipin GNDA
*.opin ROUT1
x5 V[0] V[1] V[2] V[3] V[4] V[5] V[6] V[7] V[8] V[9] V[10] V[11] V[12] V[13] V[14] V[15] V[16] V[17]
+ V[18] V[19] V[20] V[21] V[22] V[23] V[24] V[25] V[26] V[27] V[28] V[29] V[30] V[31] V[32] V[33] V[34]
+ V[35] V[36] V[37] V[38] V[39] V[40] V[41] V[42] V[43] V[44] V[45] V[46] V[47] V[48] V[49] V[50] V[51]
+ V[52] V[53] V[54] V[55] V[56] V[57] V[58] V[59] V[60] V[61] V[62] V[63] V[64] V[65] V[66] V[67] V[68]
+ V[69] V[70] V[71] V[72] V[73] V[74] V[75] V[76] V[77] V[78] V[79] V[80] V[81] V[82] V[83] V[84] V[85]
+ V[86] V[87] V[88] V[89] V[90] V[91] V[92] V[93] V[94] V[95] V[96] V[97] V[98] V[99] V[100] V[101] V[102]
+ V[103] V[104] V[105] V[106] V[107] V[108] V[109] V[110] V[111] V[112] V[113] V[114] V[115] V[116] V[117]
+ V[118] V[119] V[120] V[121] V[122] V[123] V[124] V[125] V[126] V[127] V[128] V[129] V[130] V[131] V[132]
+ V[133] V[134] V[135] V[136] V[137] V[138] V[139] V[140] V[141] V[142] V[143] V[144] V[145] V[146] V[147]
+ V[148] V[149] V[150] V[151] V[152] V[153] V[154] V[155] V[156] V[157] V[158] V[159] V[160] V[161] V[162]
+ V[163] V[164] V[165] V[166] V[167] V[168] V[169] V[170] V[171] V[172] V[173] V[174] V[175] V[176] V[177]
+ V[178] V[179] V[180] V[181] V[182] V[183] V[184] V[185] V[186] V[187] V[188] V[189] V[190] V[191] GND
+ rstring
x2 V[64] V[65] V[66] V[67] V[68] V[69] V[70] V[71] V[72] V[73] V[74] V[75] V[76] V[77] V[78] V[79]
+ V[80] V[81] V[82] V[83] V[84] V[85] V[86] V[87] V[88] V[89] V[90] V[91] V[92] V[93] V[94] V[95] V[96]
+ V[97] V[98] V[99] V[100] V[101] V[102] V[103] V[104] V[105] V[106] V[107] V[108] V[109] V[110] V[111]
+ V[112] dec0[0] dec0[1] dec0[2] dec1[0] dec1[1] dec1[2] dec1[3] dec2[0] dec2[1] dec2[2] dec2[3] VH2 VL2 GND
+ vselector_6b_2v
x3 V[112] V[113] V[114] V[115] V[116] V[117] V[118] V[119] V[120] V[121] V[122] V[123] V[124] V[125]
+ V[126] V[127] V[128] b[3] b[4] b[5] b[6] bb[3] bb[4] bb[5] bb[6] VH3 VL3 VDDH vselector_4b_2v
x4 V[128] V[129] V[130] V[131] V[132] V[133] V[134] V[135] V[136] V[137] V[138] V[139] V[140] V[141]
+ V[142] V[143] V[144] V[145] V[146] V[147] V[148] V[149] V[150] V[151] V[152] V[153] V[154] V[155] V[156]
+ V[157] V[158] V[159] V[160] V[161] V[162] V[163] V[164] V[165] V[166] V[167] V[168] V[169] V[170] V[171]
+ V[172] V[173] V[174] V[175] V[176] V[177] V[178] V[179] V[180] V[181] V[182] V[183] V[184] V[185] V[186]
+ V[187] V[188] V[189] V[190] V[191] dec2[0] dec2[1] dec2[2] dec2[3] b[0] b[1] b[2] b[3] bb[0] bb[1] bb[2]
+ bb[3] VS4 VDDH vselector_6b_1v_pmos
x6 VH2 VL2 b[0] b[1] b[2] b[3] bb[0] bb[1] bb[2] bb[3] net1[3] net1[2] net1[1] net1[0] GND
+ interpolating_dec_4b
x7 VH3 VL3 b[0] b[1] b[2] bb[0] bb[1] bb[2] net2[2] net2[1] net2[0] VDDH interpolating_dec_3b
x8 net3 net4 net5[3] net5[2] net5[1] net5[0] net6[3] net6[2] net6[1] net6[0] net7 net8[4] net8[3]
+ net8[2] net8[1] net8[0] net9[3] net9[2] net9[1] net9[0] net10 P_IN[0] P_IN[1] P_IN[2] P_IN[3] P_IN[4] net11
+ net12 net13 net14 net15 seg_selector
x9 VBPDEC VBNDEC d[8] d[9] dec0[0] dec0[1] dec0[2] dec0[3] VDD VDDH GND decoder_2to4
x10 VBPDEC VBNDEC d[6] d[7] dec1[0] dec1[1] dec1[2] dec1[3] VDD VDDH GND decoder_2to4
x11 VBPDEC VBNDEC d[4] d[5] dec2[0] dec2[1] dec2[2] dec2[3] VDD VDDH GND decoder_2to4
x16 net16 net17 net18 net19 inv_hvl m=1
x1 V[0] V[1] V[2] V[3] V[4] V[5] V[6] V[7] V[8] V[9] V[10] V[11] V[12] V[13] V[14] V[15] V[16] V[17]
+ V[18] V[19] V[20] V[21] V[22] V[23] V[24] V[25] V[26] V[27] V[28] V[29] V[30] V[31] V[32] V[33] V[34]
+ V[35] V[36] V[37] V[38] V[39] V[40] V[41] V[42] V[43] V[44] V[45] V[46] V[47] V[48] V[49] V[50] V[51]
+ V[52] V[53] V[54] V[55] V[56] V[57] V[58] V[59] V[60] V[61] V[62] V[63] dec2[0] dec2[1] dec2[2] dec2[3]
+ b[0] b[1] b[2] b[3] bb[0] bb[1] bb[2] bb[3] VS1 GND vselector_seg1
x12 VBPLV VBNLV d[0] db[0] b[0] bb[0] VDDH GND lvsf_1buff
x13 VBPLV VBNLV d[1] db[1] b[1] bb[1] VDDH GND lvsf_1buff
x14 VBPLV VBNLV d[2] db[2] b[2] bb[2] VDDH GND lvsf_1buff
x15 VBPLV VBNLV d[3] db[3] b[3] bb[3] VDDH GND lvsf_1buff
x17 P_IN[0] P_IN[1] P_IN[2] P_IN[3] P_IN[4] VOUT VOUT net20 net21 net22 op_amp
**.ends

* expanding   symbol:  rstring.sym # of pins=2
** sym_path: xschem/rstring.sym
** sch_path: xschem/rstring.sch
.subckt rstring v[0] v[1] v[2] v[3] v[4] v[5] v[6] v[7] v[8] v[9] v[10] v[11] v[12] v[13] v[14]
+ v[15] v[16] v[17] v[18] v[19] v[20] v[21] v[22] v[23] v[24] v[25] v[26] v[27] v[28] v[29] v[30] v[31]
+ v[32] v[33] v[34] v[35] v[36] v[37] v[38] v[39] v[40] v[41] v[42] v[43] v[44] v[45] v[46] v[47] v[48]
+ v[49] v[50] v[51] v[52] v[53] v[54] v[55] v[56] v[57] v[58] v[59] v[60] v[61] v[62] v[63] v[64] v[65]
+ v[66] v[67] v[68] v[69] v[70] v[71] v[72] v[73] v[74] v[75] v[76] v[77] v[78] v[79] v[80] v[81] v[82]
+ v[83] v[84] v[85] v[86] v[87] v[88] v[89] v[90] v[91] v[92] v[93] v[94] v[95] v[96] v[97] v[98] v[99]
+ v[100] v[101] v[102] v[103] v[104] v[105] v[106] v[107] v[108] v[109] v[110] v[111] v[112] v[113] v[114]
+ v[115] v[116] v[117] v[118] v[119] v[120] v[121] v[122] v[123] v[124] v[125] v[126] v[127] v[128] v[129]
+ v[130] v[131] v[132] v[133] v[134] v[135] v[136] v[137] v[138] v[139] v[140] v[141] v[142] v[143] v[144]
+ v[145] v[146] v[147] v[148] v[149] v[150] v[151] v[152] v[153] v[154] v[155] v[156] v[157] v[158] v[159]
+ v[160] v[161] v[162] v[163] v[164] v[165] v[166] v[167] v[168] v[169] v[170] v[171] v[172] v[173] v[174]
+ v[175] v[176] v[177] v[178] v[179] v[180] v[181] v[182] v[183] v[184] v[185] v[186] v[187] v[188] v[189]
+ v[190] v[191] gnd
*.opin
*+ v[0],v[1],v[2],v[3],v[4],v[5],v[6],v[7],v[8],v[9],v[10],v[11],v[12],v[13],v[14],v[15],v[16],v[17],v[18],v[19],v[20],v[21],v[22],v[23],v[24],v[25],v[26],v[27],v[28],v[29],v[30],v[31],v[32],v[33],v[34],v[35],v[36],v[37],v[38],v[39],v[40],v[41],v[42],v[43],v[44],v[45],v[46],v[47],v[48],v[49],v[50],v[51],v[52],v[53],v[54],v[55],v[56],v[57],v[58],v[59],v[60],v[61],v[62],v[63],v[64],v[65],v[66],v[67],v[68],v[69],v[70],v[71],v[72],v[73],v[74],v[75],v[76],v[77],v[78],v[79],v[80],v[81],v[82],v[83],v[84],v[85],v[86],v[87],v[88],v[89],v[90],v[91],v[92],v[93],v[94],v[95],v[96],v[97],v[98],v[99],v[100],v[101],v[102],v[103],v[104],v[105],v[106],v[107],v[108],v[109],v[110],v[111],v[112],v[113],v[114],v[115],v[116],v[117],v[118],v[119],v[120],v[121],v[122],v[123],v[124],v[125],v[126],v[127],v[128],v[129],v[130],v[131],v[132],v[133],v[134],v[135],v[136],v[137],v[138],v[139],v[140],v[141],v[142],v[143],v[144],v[145],v[146],v[147],v[148],v[149],v[150],v[151],v[152],v[153],v[154],v[155],v[156],v[157],v[158],v[159],v[160],v[161],v[162],v[163],v[164],v[165],v[166],v[167],v[168],v[169],v[170],v[171],v[172],v[173],v[174],v[175],v[176],v[177],v[178],v[179],v[180],v[181],v[182],v[183],v[184],v[185],v[186],v[187],v[188],v[189],v[190],v[191]
*.ipin gnd
x1 v[0] v[1] v[2] v[3] v[4] v[5] v[6] v[7] v[8] v[9] v[10] v[11] v[12] v[13] v[14] v[15] v[16] v[17]
+ v[18] v[19] v[20] v[21] v[22] v[23] v[24] v[25] v[26] v[27] v[28] v[29] v[30] v[31] v[32] v[33] v[34]
+ v[35] v[36] v[37] v[38] v[39] v[40] v[41] v[42] v[43] v[44] v[45] v[46] v[47] v[48] v[49] v[50] v[51]
+ v[52] v[53] v[54] v[55] v[56] v[57] v[58] v[59] v[60] v[61] v[62] v[63] v[64] gnd res_seg_1
x2 v[64] v[65] v[66] v[67] v[68] v[69] v[70] v[71] v[72] v[73] v[74] v[75] v[76] v[77] v[78] v[79]
+ v[80] v[81] v[82] v[83] v[84] v[85] v[86] v[87] v[88] v[89] v[90] v[91] v[92] v[93] v[94] v[95] v[96]
+ v[97] v[98] v[99] v[100] v[101] v[102] v[103] v[104] v[105] v[106] v[107] v[108] v[109] v[110] v[111]
+ v[112] gnd res_seg_2
x3 v[112] v[113] v[114] v[115] v[116] v[117] v[118] v[119] v[120] v[121] v[122] v[123] v[124] v[125]
+ v[126] v[127] v[128] gnd res_seg_3
x4 v[128] v[129] v[130] v[131] v[132] v[133] v[134] v[135] v[136] v[137] v[138] v[139] v[140] v[141]
+ v[142] v[143] v[144] v[145] v[146] v[147] v[148] v[149] v[150] v[151] v[152] v[153] v[154] v[155] v[156]
+ v[157] v[158] v[159] v[160] v[161] v[162] v[163] v[164] v[165] v[166] v[167] v[168] v[169] v[170] v[171]
+ v[172] v[173] v[174] v[175] v[176] v[177] v[178] v[179] v[180] v[181] v[182] v[183] v[184] v[185] v[186]
+ v[187] v[188] v[189] v[190] v[191] gnd res_seg_4
.ends


* expanding   symbol:  vselector_6b_2v.sym # of pins=7
** sym_path: xschem/vselector_6b_2v.sym
** sch_path: xschem/vselector_6b_2v.sch
.subckt vselector_6b_2v vin[0] vin[1] vin[2] vin[3] vin[4] vin[5] vin[6] vin[7] vin[8] vin[9]
+ vin[10] vin[11] vin[12] vin[13] vin[14] vin[15] vin[16] vin[17] vin[18] vin[19] vin[20] vin[21] vin[22]
+ vin[23] vin[24] vin[25] vin[26] vin[27] vin[28] vin[29] vin[30] vin[31] vin[32] vin[33] vin[34] vin[35]
+ vin[36] vin[37] vin[38] vin[39] vin[40] vin[41] vin[42] vin[43] vin[44] vin[45] vin[46] vin[47] vin[48]
+ dec0[0] dec0[1] dec0[2] dec1[0] dec1[1] dec1[2] dec1[3] dec2[0] dec2[1] dec2[2] dec2[3] VH VL VNB
*.ipin
*+ vin[0],vin[1],vin[2],vin[3],vin[4],vin[5],vin[6],vin[7],vin[8],vin[9],vin[10],vin[11],vin[12],vin[13],vin[14],vin[15],vin[16],vin[17],vin[18],vin[19],vin[20],vin[21],vin[22],vin[23],vin[24],vin[25],vin[26],vin[27],vin[28],vin[29],vin[30],vin[31],vin[32],vin[33],vin[34],vin[35],vin[36],vin[37],vin[38],vin[39],vin[40],vin[41],vin[42],vin[43],vin[44],vin[45],vin[46],vin[47],vin[48]
*.opin VH
*.ipin VNB
*.ipin dec0[0],dec0[1],dec0[2]
*.opin VL
*.ipin dec1[0],dec1[1],dec1[2],dec1[3]
*.ipin dec2[0],dec2[1],dec2[2],dec2[3]
x1 vin[0] vin[1] vin[2] vin[3] vin[4] vin[5] vin[6] vin[7] vin[8] vin[9] vin[10] vin[11] vin[12]
+ vin[13] vin[14] vin[15] vin[16] vin[17] vin[18] vin[19] vin[20] vin[21] vin[22] vin[23] vin[24] vin[25]
+ vin[26] vin[27] vin[28] vin[29] vin[30] vin[31] vin[32] vin[33] vin[34] vin[35] vin[36] vin[37] vin[38]
+ vin[39] vin[40] vin[41] vin[42] vin[43] vin[44] vin[45] vin[46] vin[47] vin[48] dec0[0] dec0[1] dec0[2]
+ vout1[0] vout1[1] vout1[2] vout1[3] vout1[4] vout1[5] vout1[6] vout1[7] vout1[8] vout1[9] vout1[10]
+ vout1[11] vout1[12] vout1[13] vout1[14] vout1[15] vout1[16] VNB vselector_6b_2v_stage_1
x2 vout1[0] vout1[1] vout1[2] vout1[3] vout1[4] vout1[5] vout1[6] vout1[7] vout1[8] vout1[9]
+ vout1[10] vout1[11] vout1[12] vout1[13] vout1[14] vout1[15] vout1[16] dec1[0] dec1[1] dec1[2] dec1[3]
+ vout2[0] vout2[1] vout2[2] vout2[3] vout2[4] VNB vselector_6b_2v_stage_2
x3 vout2[0] vout2[1] vout2[2] vout2[3] vout2[4] dec2[0] dec2[1] dec2[2] dec2[3] VH VL VNB
+ vselector_6b_2v_stage_3
.param wp=0.42 wn=0.42 l=0.5

.ends


* expanding   symbol:  vselector_4b_2v.sym # of pins=6
** sym_path: xschem/vselector_4b_2v.sym
** sch_path: xschem/vselector_4b_2v.sch
.subckt vselector_4b_2v vin[0] vin[1] vin[2] vin[3] vin[4] vin[5] vin[6] vin[7] vin[8] vin[9]
+ vin[10] vin[11] vin[12] vin[13] vin[14] vin[15] vin[16] b[3] b[4] b[5] b[6] bb[3] bb[4] bb[5] bb[6] VH VL
+ VPB
*.ipin
*+ vin[0],vin[1],vin[2],vin[3],vin[4],vin[5],vin[6],vin[7],vin[8],vin[9],vin[10],vin[11],vin[12],vin[13],vin[14],vin[15],vin[16]
*.opin VH
*.ipin VPB
*.ipin b[3],b[4],b[5],b[6]
*.opin VL
*.ipin bb[3],bb[4],bb[5],bb[6]
x1 vin[0] vin[1] vin[2] vin[3] vin[4] vin[5] vin[6] vin[7] vin[8] b[6] v1[0] v1[1] v1[2] v1[3] v1[4]
+ v1[5] v1[6] v1[7] v1[8] VPB switch_pmos_1g_9o
x2 vin[8] vin[9] vin[10] vin[11] vin[12] vin[13] vin[14] vin[15] vin[16] bb[6] v1[0] v1[1] v1[2]
+ v1[3] v1[4] v1[5] v1[6] v1[7] v1[8] VPB switch_pmos_1g_9o
x3 v1[0] v1[1] v1[2] v1[3] v1[4] b[5] v2[0] v2[1] v2[2] v2[3] v2[4] VPB switch_pmos_1g_5o
x4 v1[4] v1[5] v1[6] v1[7] v1[8] bb[5] v2[0] v2[1] v2[2] v2[3] v2[4] VPB switch_pmos_1g_5o
x5 v2[0] v2[1] v2[2] b[4] v3[0] v3[1] v3[2] VPB switch_pmos_1g_3o
x6 v2[2] v2[3] v2[4] bb[4] v3[0] v3[1] v3[2] VPB switch_pmos_1g_3o
x7 v3[0] v3[1] b[3] VH VL VPB switch_pmos_1g_2o
x8 v3[1] v3[2] bb[3] VH VL VPB switch_pmos_1g_2o
.ends


* expanding   symbol:  vselector_6b_1v_pmos.sym # of pins=6
** sym_path: xschem/vselector_6b_1v_pmos.sym
** sch_path: xschem/vselector_6b_1v_pmos.sch
.subckt vselector_6b_1v_pmos VIN[0] VIN[1] VIN[2] VIN[3] VIN[4] VIN[5] VIN[6] VIN[7] VIN[8] VIN[9]
+ VIN[10] VIN[11] VIN[12] VIN[13] VIN[14] VIN[15] VIN[16] VIN[17] VIN[18] VIN[19] VIN[20] VIN[21] VIN[22]
+ VIN[23] VIN[24] VIN[25] VIN[26] VIN[27] VIN[28] VIN[29] VIN[30] VIN[31] VIN[32] VIN[33] VIN[34] VIN[35]
+ VIN[36] VIN[37] VIN[38] VIN[39] VIN[40] VIN[41] VIN[42] VIN[43] VIN[44] VIN[45] VIN[46] VIN[47] VIN[48]
+ VIN[49] VIN[50] VIN[51] VIN[52] VIN[53] VIN[54] VIN[55] VIN[56] VIN[57] VIN[58] VIN[59] VIN[60] VIN[61]
+ VIN[62] VIN[63] DEC[0] DEC[1] DEC[2] DEC[3] b[0] b[1] b[2] b[3] bb[0] bb[1] bb[2] bb[3] VOUT VPB
*.ipin
*+ VIN[0],VIN[1],VIN[2],VIN[3],VIN[4],VIN[5],VIN[6],VIN[7],VIN[8],VIN[9],VIN[10],VIN[11],VIN[12],VIN[13],VIN[14],VIN[15],VIN[16],VIN[17],VIN[18],VIN[19],VIN[20],VIN[21],VIN[22],VIN[23],VIN[24],VIN[25],VIN[26],VIN[27],VIN[28],VIN[29],VIN[30],VIN[31],VIN[32],VIN[33],VIN[34],VIN[35],VIN[36],VIN[37],VIN[38],VIN[39],VIN[40],VIN[41],VIN[42],VIN[43],VIN[44],VIN[45],VIN[46],VIN[47],VIN[48],VIN[49],VIN[50],VIN[51],VIN[52],VIN[53],VIN[54],VIN[55],VIN[56],VIN[57],VIN[58],VIN[59],VIN[60],VIN[61],VIN[62],VIN[63]
*.opin VOUT
*.ipin VPB
*.ipin DEC[0],DEC[1],DEC[2],DEC[3]
*.ipin b[0],b[1],b[2],b[3]
*.ipin bb[0],bb[1],bb[2],bb[3]
x1 VIN[0] VIN[1] VIN[2] VIN[3] VIN[4] VIN[5] VIN[6] VIN[7] VIN[8] VIN[9] VIN[10] VIN[11] VIN[12]
+ VIN[13] VIN[14] VIN[15] VIN[16] VIN[17] VIN[18] VIN[19] VIN[20] VIN[21] VIN[22] VIN[23] VIN[24] VIN[25]
+ VIN[26] VIN[27] VIN[28] VIN[29] VIN[30] VIN[31] VIN[32] VIN[33] VIN[34] VIN[35] VIN[36] VIN[37] VIN[38]
+ VIN[39] VIN[40] VIN[41] VIN[42] VIN[43] VIN[44] VIN[45] VIN[46] VIN[47] VIN[48] VIN[49] VIN[50] VIN[51]
+ VIN[52] VIN[53] VIN[54] VIN[55] VIN[56] VIN[57] VIN[58] VIN[59] VIN[60] VIN[61] VIN[62] VIN[63] DEC[0]
+ DEC[1] DEC[2] DEC[3] v1[0] v1[1] v1[2] v1[3] v1[4] v1[5] v1[6] v1[7] v1[8] v1[9] v1[10] v1[11] v1[12]
+ v1[13] v1[14] v1[15] VPB vselector_6b_1v_stage_1_pmos
x2 v1[0] v1[1] v1[2] v1[3] v1[4] v1[5] v1[6] v1[7] b[3] v2[0] v2[1] v2[2] v2[3] v2[4] v2[5] v2[6]
+ v2[7] VPB switch_pmos_1g_8o
x3 v1[8] v1[9] v1[10] v1[11] v1[12] v1[13] v1[14] v1[15] bb[3] v2[0] v2[1] v2[2] v2[3] v2[4] v2[5]
+ v2[6] v2[7] VPB switch_pmos_1g_8o
x4 v2[0] v2[1] v2[2] v2[3] b[2] v3[0] v3[1] v3[2] v3[3] VPB switch_pmos_1g_4o
x5 v2[4] v2[5] v2[6] v2[7] bb[2] v3[0] v3[1] v3[2] v3[3] VPB switch_pmos_1g_4o
x6 v3[0] v3[1] b[1] v4[1] v4[0] VPB switch_pmos_1g_2o
x7 v3[2] v3[3] bb[1] v4[1] v4[0] VPB switch_pmos_1g_2o
x8 v4[0] v4[1] b[0] bb[0] VOUT VPB switch_pmos_2g_1o
.ends


* expanding   symbol:  interpolating_dec_4b.sym # of pins=6
** sym_path: xschem/interpolating_dec_4b.sym
** sch_path: xschem/interpolating_dec_4b.sch
.subckt interpolating_dec_4b VH VL b[0] b[1] b[2] b[3] bb[0] bb[1] bb[2] bb[3] vout[0] vout[1]
+ vout[2] vout[3] VNB
*.opin vout[0],vout[1],vout[2],vout[3]
*.ipin VNB
*.ipin b[0],b[1],b[2],b[3]
*.ipin VH
*.ipin VL
*.ipin bb[0],bb[1],bb[2],bb[3]
.param wp=0.42 wn=0.42 l=0.5

XM1 vout[0] b[0] VH VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM2 vout[1] b[1] VH VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM3 vout[2] b[2] VH VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM4 vout[3] b[3] VH VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM5 vout[0] bb[0] VL VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM6 vout[1] bb[1] VL VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM7 vout[2] bb[2] VL VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM8 vout[3] bb[3] VL VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  interpolating_dec_3b.sym # of pins=6
** sym_path: xschem/interpolating_dec_3b.sym
** sch_path: xschem/interpolating_dec_3b.sch
.subckt interpolating_dec_3b VH VL b[0] b[1] b[2] bb[0] bb[1] bb[2] vout[0] vout[1] vout[2] VPB
*.opin vout[0],vout[1],vout[2]
*.ipin b[0],b[1],b[2]
*.ipin VPB
*.ipin VH
*.ipin VL
*.ipin bb[0],bb[1],bb[2]
.param wp=0.42 wn=0.42 l=0.5

XM5 vout[0] b[0] VL VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM6 vout[1] b[1] VL VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM7 vout[2] b[2] VL VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM1 vout[0] bb[0] VH VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM2 vout[1] bb[1] VH VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM3 vout[2] bb[2] VH VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  seg_selector.sym # of pins=14
** sym_path: xschem/seg_selector.sym
** sch_path: xschem/seg_selector.sch
.subckt seg_selector VPBIAS VNBIAS b[6] b[7] b[8] b[9] bb[6] bb[7] bb[8] bb[9] VS1 VS2[0] VS2[1]
+ VS2[2] VS2[3] VS2[4] VS3[0] VS3[1] VS3[2] VS3[3] VS4 vout[0] vout[1] vout[2] vout[3] vout[4] VDD VDDH GND
+ VPB VNB
*.opin vout[0],vout[1],vout[2],vout[3],vout[4]
*.ipin VNB
*.ipin VPB
*.ipin b[6],b[7],b[8],b[9]
*.ipin VS1
*.ipin VS2[0],VS2[1],VS2[2],VS2[3],VS2[4]
*.ipin VS3[0],VS3[1],VS3[2],VS3[3]
*.ipin VS4
*.ipin bb[6],bb[7],bb[8],bb[9]
*.ipin GND
*.ipin VDD
*.ipin VPBIAS
*.ipin VNBIAS
*.ipin VDDH
x1 SH[1] VS1 vout[0] vout[1] vout[2] vout[3] vout[4] VNB seg_selector_1
x2 SH[2] VS2[0] VS2[1] VS2[2] VS2[3] VS2[4] vout[0] vout[1] vout[2] vout[3] vout[4] VNB
+ seg_selector_2
x3 SH[3] VS3[0] VS3[1] VS3[2] VS3[3] vout[0] vout[1] vout[2] vout[3] vout[4] VPB seg_selector_3
x4 SH[4] VS4 vout[0] vout[1] vout[2] vout[3] vout[4] VPB seg_selector_4
x5 b[6] b[7] b[8] b[9] bb[6] bb[7] bb[8] bb[9] S[1] S[2] S[3] S[4] VDD GND seg_selector_logic
x6 VPBIAS VNBIAS S[4] SB[4] net4 VDDH GND lvsf
x7 VPBIAS VNBIAS S[3] SB[3] net3 VDDH GND lvsf
x8 VPBIAS VNBIAS SB[2] S[2] net2 VDDH GND lvsf
x9 VPBIAS VNBIAS SB[1] S[1] net1 VDDH GND lvsf
x10 S[1] GND GND VDD VDD SB[1] sky130_fd_sc_hd__inv_1
x11 S[2] GND GND VDD VDD SB[2] sky130_fd_sc_hd__inv_1
x12 S[3] GND GND VDD VDD SB[3] sky130_fd_sc_hd__inv_1
x13 S[4] GND GND VDD VDD SB[4] sky130_fd_sc_hd__inv_1
x14 net1 SH[1] VDDH GND inv_hvl m=1
x15 net2 SH[2] VDDH GND inv_hvl m=1
x16 net3 SH[3] VDDH GND inv_hvl m=1
x17 net4 SH[4] VDDH GND inv_hvl m=1
.ends


* expanding   symbol:  decoder_2to4.sym # of pins=7
** sym_path: xschem/decoder_2to4.sym
** sch_path: xschem/decoder_2to4.sch
.subckt decoder_2to4 VPBIAS VNBIAS b[0] b[1] VOUT[0] VOUT[1] VOUT[2] VOUT[3] VDD VDDH GND
*.ipin VPBIAS
*.ipin VNBIAS
*.ipin b[0],b[1]
*.opin VOUT[0],VOUT[1],VOUT[2],VOUT[3]
*.ipin VDDH
*.ipin GND
*.ipin VDD
x1 VPBIAS VNBIAS DIN[0] VOUT[1] VOUT[2] VOUT[3] VOUT[0] VDDH GND VDDH GND pull_up_down_network
x2 VPBIAS VNBIAS DIN[1] VOUT[0] VOUT[2] VOUT[3] VOUT[1] VDDH GND VDDH GND pull_up_down_network
x3 VPBIAS VNBIAS DIN[2] VOUT[0] VOUT[1] VOUT[3] VOUT[2] VDDH GND VDDH GND pull_up_down_network
x4 VPBIAS VNBIAS DIN[3] VOUT[0] VOUT[1] VOUT[2] VOUT[3] VDDH GND VDDH GND pull_up_down_network
x6 bb[0] bb[1] GND GND VDD VDD DIN[0] sky130_fd_sc_hd__nand2_1
x7 b[0] bb[1] GND GND VDD VDD DIN[1] sky130_fd_sc_hd__nand2_1
x8 bb[0] b[1] GND GND VDD VDD DIN[2] sky130_fd_sc_hd__nand2_1
x9 b[0] b[1] GND GND VDD VDD DIN[3] sky130_fd_sc_hd__nand2_1
x5 b[0] GND GND VDD VDD bb[0] sky130_fd_sc_hd__inv_1
x10 b[1] GND GND VDD VDD bb[1] sky130_fd_sc_hd__inv_1
.ends


* expanding   symbol:  inv_hvl.sym # of pins=4
** sym_path: xschem/inv_hvl.sym
** sch_path: xschem/inv_hvl.sch
.subckt inv_hvl in out VDDH GND
*.opin out
*.ipin VDDH
*.ipin GND
*.ipin in
.param wp=0.84 wn=0.42 l=0.5
XM1 out in VDDH VDDH sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=m m=m
XM2 out in GND GND sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=m m=m
.ends


* expanding   symbol:  vselector_seg1.sym # of pins=6
** sym_path: xschem/vselector_seg1.sym
** sch_path: xschem/vselector_seg1.sch
.subckt vselector_seg1 vin[0] vin[1] vin[2] vin[3] vin[4] vin[5] vin[6] vin[7] vin[8] vin[9] vin[10]
+ vin[11] vin[12] vin[13] vin[14] vin[15] vin[16] vin[17] vin[18] vin[19] vin[20] vin[21] vin[22] vin[23]
+ vin[24] vin[25] vin[26] vin[27] vin[28] vin[29] vin[30] vin[31] vin[32] vin[33] vin[34] vin[35] vin[36]
+ vin[37] vin[38] vin[39] vin[40] vin[41] vin[42] vin[43] vin[44] vin[45] vin[46] vin[47] vin[48] vin[49]
+ vin[50] vin[51] vin[52] vin[53] vin[54] vin[55] vin[56] vin[57] vin[58] vin[59] vin[60] vin[61] vin[62]
+ vin[63] dec0[0] dec0[1] dec0[2] dec0[3] b[0] b[1] b[2] b[3] bb[0] bb[1] bb[2] bb[3] VOUT VNB
*.ipin
*+ vin[0],vin[1],vin[2],vin[3],vin[4],vin[5],vin[6],vin[7],vin[8],vin[9],vin[10],vin[11],vin[12],vin[13],vin[14],vin[15],vin[16],vin[17],vin[18],vin[19],vin[20],vin[21],vin[22],vin[23],vin[24],vin[25],vin[26],vin[27],vin[28],vin[29],vin[30],vin[31],vin[32],vin[33],vin[34],vin[35],vin[36],vin[37],vin[38],vin[39],vin[40],vin[41],vin[42],vin[43],vin[44],vin[45],vin[46],vin[47],vin[48],vin[49],vin[50],vin[51],vin[52],vin[53],vin[54],vin[55],vin[56],vin[57],vin[58],vin[59],vin[60],vin[61],vin[62],vin[63]
*.opin VOUT
*.ipin VNB
*.ipin dec0[0],dec0[1],dec0[2],dec0[3]
*.ipin b[0],b[1],b[2],b[3]
*.ipin bb[0],bb[1],bb[2],bb[3]
x1 vin[0] vin[1] vin[2] vin[3] vin[4] vin[5] vin[6] vin[7] vin[8] vin[9] vin[10] vin[11] vin[12]
+ vin[13] vin[14] vin[15] vin[16] vin[17] vin[18] vin[19] vin[20] vin[21] vin[22] vin[23] vin[24] vin[25]
+ vin[26] vin[27] vin[28] vin[29] vin[30] vin[31] vin[32] vin[33] vin[34] vin[35] vin[36] vin[37] vin[38]
+ vin[39] vin[40] vin[41] vin[42] vin[43] vin[44] vin[45] vin[46] vin[47] vin[48] vin[49] vin[50] vin[51]
+ vin[52] vin[53] vin[54] vin[55] vin[56] vin[57] vin[58] vin[59] vin[60] vin[61] vin[62] vin[63] dec0[0]
+ dec0[1] dec0[2] dec0[3] v1[0] v1[1] v1[2] v1[3] v1[4] v1[5] v1[6] v1[7] v1[8] v1[9] v1[10] v1[11] v1[12]
+ v1[13] v1[14] v1[15] VNB vselector_6b_1v_stage_1
x2 v1[0] v1[1] v1[2] v1[3] v1[4] v1[5] v1[6] v1[7] bb[3] v2[0] v2[1] v2[2] v2[3] v2[4] v2[5] v2[6]
+ v2[7] VNB switch_nmos_1g_8o
x3 v1[8] v1[9] v1[10] v1[11] v1[12] v1[13] v1[14] v1[15] b[3] v2[0] v2[1] v2[2] v2[3] v2[4] v2[5]
+ v2[6] v2[7] VNB switch_nmos_1g_8o
x4 v2[0] v2[1] v2[2] v2[3] bb[2] v3[0] v3[1] v3[2] v3[3] VNB switch_nmos_1g_4o
x5 v2[4] v2[5] v2[6] v2[7] b[2] v3[0] v3[1] v3[2] v3[3] VNB switch_nmos_1g_4o
x6 v3[0] v3[1] bb[1] v4[0] v4[1] VNB switch_nmos_1g_2o
x7 v3[2] v3[3] b[1] v4[0] v4[1] VNB switch_nmos_1g_2o
x8 v4[0] v4[1] b[0] bb[0] vout vout VNB switch_nmos_2g_2o
.ends


* expanding   symbol:  lvsf_1buff.sym # of pins=8
** sym_path: xschem/lvsf_1buff.sym
** sch_path: xschem/lvsf_1buff.sch
.subckt lvsf_1buff VPBIAS VNBIAS IN INB OUT OUTB VDDH GND
*.ipin IN
*.ipin INB
*.opin OUT
*.ipin VDDH
*.ipin GND
*.ipin VPBIAS
*.ipin VNBIAS
*.opin OUTB
Vmeas net1 net2 0
.save i(vmeas)
XM13 net6 IN GND GND sky130_fd_pr__nfet_01v8 L=0.15 W=3 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM1 net3 VPBIAS VDDH VDDH sky130_fd_pr__pfet_g5v0d10v5 L=0.8 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM2 net1 VPBIAS VDDH VDDH sky130_fd_pr__pfet_g5v0d10v5 L=0.8 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM3 OUTPB OUTP net4 VDDH sky130_fd_pr__pfet_g5v0d10v5 L=0.8 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM4 OUTP OUTPB net2 VDDH sky130_fd_pr__pfet_g5v0d10v5 L=0.8 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM5 OUTPB VNBIAS n1 GND sky130_fd_pr__nfet_g5v0d10v5 L=1 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM6 OUTP VNBIAS n2 GND sky130_fd_pr__nfet_g5v0d10v5 L=1 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
Vmeas1 net3 net4 0
.save i(vmeas1)
XM7 net5 INB GND GND sky130_fd_pr__nfet_01v8 L=0.15 W=3 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
Vmeas2 n2 net5 0
.save i(vmeas2)
Vmeas3 n1 net6 0
.save i(vmeas3)
x1 OUTP OUTB VDDH GND inv_hvl m=1
x2 OUTB OUT VDDH GND inv_hvl m=1
.ends


* expanding   symbol:  op_amp.sym # of pins=6
** sym_path: xschem/op_amp.sym
** sch_path: xschem/op_amp.sch
.subckt op_amp P_IN[0] P_IN[1] P_IN[2] P_IN[3] P_IN[4] N_IN VOUT ROUT VDDA GNDA
*.ipin P_IN[0],P_IN[1],P_IN[2],P_IN[3],P_IN[4]
*.ipin ROUT
*.opin VOUT
*.ipin VDDA
*.ipin GNDA
*.ipin N_IN
x7 VHEAD1 VHEAD2 I_HEAD0 VDDA head mv=2
x8 VHEAD1 VHEAD2 I_HEAD1 VDDA head mv=2
x9 VHEAD1 VHEAD2 I_HEAD2 VDDA head mv=4
x10 VHEAD1 VHEAD2 I_HEAD3 VDDA head mv=8
x11 VHEAD1 VHEAD2 I_HEAD4 VDDA head mv=16
x12 VTAIL1 VTAIL2 I_TAIL0 GNDA tail mv=2
x13 VTAIL1 VTAIL2 I_TAIL1 GNDA tail mv=2
x14 VTAIL1 VTAIL2 I_TAIL2 GNDA tail mv=4
x15 VTAIL1 VTAIL2 I_TAIL3 GNDA tail mv=8
x16 VTAIL1 VTAIL2 I_TAIL4 GNDA tail mv=16
x6 VHEAD2 VTAIL2 VBS1 VBS2 I_OPA I_OPB I_ONA I_ONB VOUT VDDA GNDA folded_cascode
x4 P_IN[1] N_IN I_OPA I_OPB I_ONA I_ONB I_HEAD1 I_TAIL1 VDDA GNDA diff_pair
x5 P_IN[0] N_IN I_OPA I_OPB I_ONA I_ONB I_HEAD0 I_TAIL0 VDDA GNDA diff_pair
x18 ROUT VHEAD1 VHEAD2 VTAIL1 VTAIL2 VBS1 VBS2 VDDA GNDA bias_opamp
x1 P_IN[3] N_IN I_OPA I_OPB I_ONA I_ONB I_HEAD3 I_TAIL3 VDDA GNDA diff_pair
x2 P_IN[2] N_IN I_OPA I_OPB I_ONA I_ONB I_HEAD2 I_TAIL2 VDDA GNDA diff_pair
x3 P_IN[4] N_IN I_OPA I_OPB I_ONA I_ONB I_HEAD4 I_TAIL4 VDDA GNDA diff_pair
XC1 I_ONA VOUT sky130_fd_pr__cap_mim_m3_1 W=2 L=2 MF=20 m=20
XC2 I_OPA VOUT sky130_fd_pr__cap_mim_m3_1 W=2 L=2 MF=20 m=20
XC3 GNDA GNDA sky130_fd_pr__cap_mim_m3_1 W=2 L=2 MF=38 m=38
.ends


* expanding   symbol:  res_seg_1.sym # of pins=2
** sym_path: xschem/res_seg_1.sym
** sch_path: xschem/res_seg_1.sch
.subckt res_seg_1 v[0] v[1] v[2] v[3] v[4] v[5] v[6] v[7] v[8] v[9] v[10] v[11] v[12] v[13] v[14]
+ v[15] v[16] v[17] v[18] v[19] v[20] v[21] v[22] v[23] v[24] v[25] v[26] v[27] v[28] v[29] v[30] v[31]
+ v[32] v[33] v[34] v[35] v[36] v[37] v[38] v[39] v[40] v[41] v[42] v[43] v[44] v[45] v[46] v[47] v[48]
+ v[49] v[50] v[51] v[52] v[53] v[54] v[55] v[56] v[57] v[58] v[59] v[60] v[61] v[62] v[63] v[64] gnd
*.opin
*+ v[0],v[1],v[2],v[3],v[4],v[5],v[6],v[7],v[8],v[9],v[10],v[11],v[12],v[13],v[14],v[15],v[16],v[17],v[18],v[19],v[20],v[21],v[22],v[23],v[24],v[25],v[26],v[27],v[28],v[29],v[30],v[31],v[32],v[33],v[34],v[35],v[36],v[37],v[38],v[39],v[40],v[41],v[42],v[43],v[44],v[45],v[46],v[47],v[48],v[49],v[50],v[51],v[52],v[53],v[54],v[55],v[56],v[57],v[58],v[59],v[60],v[61],v[62],v[63],v[64]
*.ipin gnd
XR1 v[1] v[0] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.8375 mult=1 m=1
XR2 v[2] v[1] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.7349 mult=1 m=1
XR3 v[3] v[2] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.6495 mult=1 m=1
XR4 v[4] v[3] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.5897 mult=1 m=1
XR8 v[7] v[8] gnd sky130_fd_pr__res_xhigh_po_0p69 L=0.8761 mult=1 m=1
XR9 v[8] v[9] gnd sky130_fd_pr__res_xhigh_po_0p69 L=0.8255 mult=1 m=1
XR10 v[9] v[10] gnd sky130_fd_pr__res_xhigh_po_0p69 L=0.775 mult=1 m=1
XR11 v[10] v[11] gnd sky130_fd_pr__res_xhigh_po_0p69 L=0.7413 mult=1 m=1
XR12 v[11] v[12] gnd sky130_fd_pr__res_xhigh_po_0p69 L=0.7076 mult=1 m=1
XR13 v[12] v[13] gnd sky130_fd_pr__res_xhigh_po_0p69 L=0.6739 mult=1 m=1
XR14 v[13] v[14] gnd sky130_fd_pr__res_xhigh_po_0p69 L=0.657 mult=1 m=1
XR15 v[14] v[15] gnd sky130_fd_pr__res_xhigh_po_0p69 L=0.6234 mult=1 m=1
XR16 v[15] v[16] gnd sky130_fd_pr__res_xhigh_po_0p69 L=0.6065 mult=1 m=1
XR17 v[16] v[17] gnd sky130_fd_pr__res_xhigh_po_0p69 L=0.5728 mult=1 m=1
XR19 v[18] v[19] gnd sky130_fd_pr__res_xhigh_po_0p69 L=0.5391 mult=1 m=1
XR27 v[26] v[27] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.8951 mult=1 m=1
XR29 v[28] v[29] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.8607 mult=1 m=1
XR31 v[30] v[31] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.8263 mult=1 m=1
XR33 v[32] v[33] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.7918 mult=1 m=1
XR36 v[35] v[36] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.7574 mult=1 m=1
XR37 v[36] v[37] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.723 mult=1 m=1
XR40 v[39] v[40] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.6885 mult=1 m=1
XR41 v[40] v[41] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.723 mult=1 m=1
XR42 v[41] v[42] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.6885 mult=1 m=1
XR43 v[42] v[43] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.6541 mult=1 m=1
XR45 v[44] v[45] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.6541 mult=1 m=1
XR48 v[47] v[48] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.6197 mult=1 m=1
XR49 v[48] v[49] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.6541 mult=1 m=1
XR51 v[50] v[51] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.5853 mult=1 m=1
XR52 v[51] v[52] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.6197 mult=1 m=1
XR53 v[52] v[53] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.5853 mult=1 m=1
XR58 v[57] v[58] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.5508 mult=1 m=1
XR64 v[63] v[64] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.5164 mult=1 m=1
XR5 v[5] v[4] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.5469 mult=1 m=1
XR6 v[6] v[5] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.5042 mult=1 m=1
XR21 v[20] v[21] gnd sky130_fd_pr__res_xhigh_po_0p69 L=0.5054 mult=1 m=1
XR54 v[53] v[54] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.5853 mult=1 m=1
XR7 v[6] v[7] gnd sky130_fd_pr__res_xhigh_po_0p69 L=0.9266 mult=1 m=1
XR18 v[17] v[18] gnd sky130_fd_pr__res_xhigh_po_0p69 L=0.5728 mult=1 m=1
XR20 v[19] v[20] gnd sky130_fd_pr__res_xhigh_po_0p69 L=0.5391 mult=1 m=1
XR22 v[21] v[22] gnd sky130_fd_pr__res_xhigh_po_0p69 L=0.5054 mult=1 m=1
XR23 v[22] v[23] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.9984 mult=1 m=1
XR24 v[23] v[24] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.9984 mult=1 m=1
XR25 v[24] v[25] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.9295 mult=1 m=1
XR26 v[25] v[26] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.9295 mult=1 m=1
XR28 v[27] v[28] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.8951 mult=1 m=1
XR30 v[29] v[30] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.8607 mult=1 m=1
XR32 v[31] v[32] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.8263 mult=1 m=1
XR34 v[33] v[34] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.7918 mult=1 m=1
XR35 v[34] v[35] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.7918 mult=1 m=1
XR38 v[37] v[38] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.7574 mult=1 m=1
XR39 v[38] v[39] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.723 mult=1 m=1
XR44 v[43] v[44] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.6885 mult=1 m=1
XR46 v[45] v[46] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.6541 mult=1 m=1
XR47 v[46] v[47] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.6541 mult=1 m=1
XR50 v[49] v[50] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.6197 mult=1 m=1
XR55 v[54] v[55] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.5853 mult=1 m=1
XR56 v[55] v[56] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.5853 mult=1 m=1
XR57 v[56] v[57] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.5853 mult=1 m=1
XR59 v[58] v[59] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.5508 mult=1 m=1
XR60 v[59] v[60] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.5508 mult=1 m=1
XR61 v[60] v[61] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.5508 mult=1 m=1
XR62 v[61] v[62] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.5508 mult=1 m=1
XR63 v[62] v[63] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.5508 mult=1 m=1
.ends


* expanding   symbol:  res_seg_2.sym # of pins=2
** sym_path: xschem/res_seg_2.sym
** sch_path: xschem/res_seg_2.sch
.subckt res_seg_2 v[0] v[1] v[2] v[3] v[4] v[5] v[6] v[7] v[8] v[9] v[10] v[11] v[12] v[13] v[14]
+ v[15] v[16] v[17] v[18] v[19] v[20] v[21] v[22] v[23] v[24] v[25] v[26] v[27] v[28] v[29] v[30] v[31]
+ v[32] v[33] v[34] v[35] v[36] v[37] v[38] v[39] v[40] v[41] v[42] v[43] v[44] v[45] v[46] v[47] v[48] gnd
*.opin
*+ v[0],v[1],v[2],v[3],v[4],v[5],v[6],v[7],v[8],v[9],v[10],v[11],v[12],v[13],v[14],v[15],v[16],v[17],v[18],v[19],v[20],v[21],v[22],v[23],v[24],v[25],v[26],v[27],v[28],v[29],v[30],v[31],v[32],v[33],v[34],v[35],v[36],v[37],v[38],v[39],v[40],v[41],v[42],v[43],v[44],v[45],v[46],v[47],v[48]
*.ipin gnd
XR1 v[1] v[0] gnd sky130_fd_pr__res_xhigh_po_0p35 L=1.9570 mult=1 m=1
XR2 v[2] v[1] gnd sky130_fd_pr__res_xhigh_po_0p35 L=1.7348 mult=1 m=1
XR3 v[3] v[2] gnd sky130_fd_pr__res_xhigh_po_0p35 L=1.5639 mult=1 m=1
XR4 v[4] v[3] gnd sky130_fd_pr__res_xhigh_po_0p35 L=1.4442 mult=1 m=1
XR5 v[5] v[4] gnd sky130_fd_pr__res_xhigh_po_0p35 L=1.3417 mult=1 m=1
XR6 v[6] v[5] gnd sky130_fd_pr__res_xhigh_po_0p35 L=1.2648 mult=1 m=1
XR7 v[7] v[6] gnd sky130_fd_pr__res_xhigh_po_0p35 L=1.1964 mult=1 m=1
XR8 v[8] v[7] gnd sky130_fd_pr__res_xhigh_po_0p35 L=1.1366 mult=1 m=1
XR9 v[9] v[8] gnd sky130_fd_pr__res_xhigh_po_0p35 L=1.0853 mult=1 m=1
XR10 v[10] v[9] gnd sky130_fd_pr__res_xhigh_po_0p35 L=1.0511 mult=1 m=1
XR11 v[11] v[10] gnd sky130_fd_pr__res_xhigh_po_0p35 L=1.0169 mult=1 m=1
XR12 v[12] v[11] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.9828 mult=1 m=1
XR13 v[13] v[12] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.9571 mult=1 m=1
XR14 v[14] v[13] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.94 mult=1 m=1
XR15 v[15] v[14] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.9144 mult=1 m=1
XR16 v[16] v[15] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.8888 mult=1 m=1
XR17 v[17] v[16] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.8802 mult=1 m=1
XR18 v[18] v[17] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.8717 mult=1 m=1
XR19 v[19] v[18] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.8546 mult=1 m=1
XR20 v[20] v[19] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.8375 mult=1 m=1
XR22 v[22] v[21] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.8289 mult=1 m=1
XR23 v[23] v[22] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.8204 mult=1 m=1
XR24 v[24] v[23] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.8118 mult=1 m=1
XR33 v[33] v[32] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.8204 mult=1 m=1
XR35 v[35] v[34] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.8289 mult=1 m=1
XR36 v[36] v[35] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.8375 mult=1 m=1
XR38 v[38] v[37] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.8631 mult=1 m=1
XR40 v[40] v[39] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.8888 mult=1 m=1
XR41 v[41] v[40] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.8973 mult=1 m=1
XR42 v[42] v[41] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.9144 mult=1 m=1
XR43 v[43] v[42] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.94 mult=1 m=1
XR44 v[44] v[43] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.9571 mult=1 m=1
XR45 v[45] v[44] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.9828 mult=1 m=1
XR46 v[46] v[45] gnd sky130_fd_pr__res_xhigh_po_0p35 L=1.0084 mult=1 m=1
XR47 v[47] v[46] gnd sky130_fd_pr__res_xhigh_po_0p35 L=1.0426 mult=1 m=1
XR48 v[48] v[47] gnd sky130_fd_pr__res_xhigh_po_0p35 L=1.0853 mult=1 m=1
XR37 v[37] v[36] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.846 mult=1 m=1
XR21 v[21] v[20] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.8375 mult=1 m=1
XR25 v[25] v[24] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.8118 mult=1 m=1
XR26 v[26] v[25] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.8118 mult=1 m=1
XR27 v[27] v[26] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.8033 mult=1 m=1
XR28 v[28] v[27] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.8118 mult=1 m=1
XR29 v[29] v[28] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.8033 mult=1 m=1
XR30 v[30] v[29] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.8033 mult=1 m=1
XR31 v[31] v[30] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.8118 mult=1 m=1
XR32 v[32] v[31] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.8118 mult=1 m=1
XR34 v[34] v[33] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.8204 mult=1 m=1
XR39 v[39] v[38] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.8631 mult=1 m=1
.ends


* expanding   symbol:  res_seg_3.sym # of pins=2
** sym_path: xschem/res_seg_3.sym
** sch_path: xschem/res_seg_3.sch
.subckt res_seg_3 v[0] v[1] v[2] v[3] v[4] v[5] v[6] v[7] v[8] v[9] v[10] v[11] v[12] v[13] v[14]
+ v[15] v[16] gnd
*.opin v[0],v[1],v[2],v[3],v[4],v[5],v[6],v[7],v[8],v[9],v[10],v[11],v[12],v[13],v[14],v[15],v[16]
*.ipin gnd
XR1 v[0] v[1] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.5555 mult=1 m=1
XR2 v[1] v[2] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.5726 mult=1 m=1
XR3 v[2] v[3] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.5811 mult=1 m=1
XR4 v[3] v[4] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.5897 mult=1 m=1
XR5 v[4] v[5] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.6153 mult=1 m=1
XR6 v[5] v[6] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.6238 mult=1 m=1
XR7 v[6] v[7] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.6409 mult=1 m=1
XR8 v[7] v[8] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.6666 mult=1 m=1
XR9 v[8] v[9] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.6837 mult=1 m=1
XR10 v[9] v[10] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.7093 mult=1 m=1
XR11 v[10] v[11] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.7264 mult=1 m=1
XR12 v[11] v[12] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.7691 mult=1 m=1
XR13 v[12] v[13] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.7948 mult=1 m=1
XR14 v[13] v[14] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.8375 mult=1 m=1
XR15 v[14] v[15] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.8802 mult=1 m=1
XR16 v[15] v[16] gnd sky130_fd_pr__res_xhigh_po_0p35 L=0.9315 mult=1 m=1
.ends


* expanding   symbol:  res_seg_4.sym # of pins=2
** sym_path: xschem/res_seg_4.sym
** sch_path: xschem/res_seg_4.sch
.subckt res_seg_4 v[0] v[1] v[2] v[3] v[4] v[5] v[6] v[7] v[8] v[9] v[10] v[11] v[12] v[13] v[14]
+ v[15] v[16] v[17] v[18] v[19] v[20] v[21] v[22] v[23] v[24] v[25] v[26] v[27] v[28] v[29] v[30] v[31]
+ v[32] v[33] v[34] v[35] v[36] v[37] v[38] v[39] v[40] v[41] v[42] v[43] v[44] v[45] v[46] v[47] v[48]
+ v[49] v[50] v[51] v[52] v[53] v[54] v[55] v[56] v[57] v[58] v[59] v[60] v[61] v[62] v[63] gnd
*.opin
*+ v[0],v[1],v[2],v[3],v[4],v[5],v[6],v[7],v[8],v[9],v[10],v[11],v[12],v[13],v[14],v[15],v[16],v[17],v[18],v[19],v[20],v[21],v[22],v[23],v[24],v[25],v[26],v[27],v[28],v[29],v[30],v[31],v[32],v[33],v[34],v[35],v[36],v[37],v[38],v[39],v[40],v[41],v[42],v[43],v[44],v[45],v[46],v[47],v[48],v[49],v[50],v[51],v[52],v[53],v[54],v[55],v[56],v[57],v[58],v[59],v[60],v[61],v[62],v[63]
*.ipin gnd
XR7 v[6] v[7] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.5164 mult=1 m=1
XR10 v[9] v[10] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.5508 mult=1 m=1
XR17 v[16] v[17] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.5853 mult=1 m=1
XR28 v[27] v[28] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.6541 mult=1 m=1
XR31 v[30] v[31] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.6885 mult=1 m=1
XR36 v[35] v[36] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.7574 mult=1 m=1
XR37 v[36] v[37] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.723 mult=1 m=1
XR40 v[39] v[40] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.7918 mult=1 m=1
XR43 v[42] v[43] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.8263 mult=1 m=1
XR44 v[43] v[44] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.8607 mult=1 m=1
XR46 v[45] v[46] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.8951 mult=1 m=1
XR51 v[50] v[51] gnd sky130_fd_pr__res_xhigh_po_0p69 L=0.5054 mult=1 m=1
XR53 v[52] v[53] gnd sky130_fd_pr__res_xhigh_po_0p69 L=0.5391 mult=1 m=1
XR55 v[54] v[55] gnd sky130_fd_pr__res_xhigh_po_0p69 L=0.5728 mult=1 m=1
XR56 v[55] v[56] gnd sky130_fd_pr__res_xhigh_po_0p69 L=0.5897 mult=1 m=1
XR57 v[56] v[57] gnd sky130_fd_pr__res_xhigh_po_0p69 L=0.6234 mult=1 m=1
XR58 v[57] v[58] gnd sky130_fd_pr__res_xhigh_po_0p69 L=0.6402 mult=1 m=1
XR59 v[58] v[59] gnd sky130_fd_pr__res_xhigh_po_0p69 L=0.6907 mult=1 m=1
XR60 v[59] v[60] gnd sky130_fd_pr__res_xhigh_po_0p69 L=0.7244 mult=1 m=1
XR61 v[60] v[61] gnd sky130_fd_pr__res_xhigh_po_0p69 L=0.7581 mult=1 m=1
XR8 v[7] v[8] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.5164 mult=1 m=1
XR11 v[10] v[11] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.5164 mult=1 m=1
XR12 v[11] v[12] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.5508 mult=1 m=1
XR13 v[12] v[13] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.5164 mult=1 m=1
XR23 v[22] v[23] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.6197 mult=1 m=1
XR34 v[33] v[34] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.723 mult=1 m=1
XR41 v[40] v[41] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.7918 mult=1 m=1
XR1 v[0] v[1] gnd sky130_fd_pr__res_xhigh_po_2p85 L=0.9742 mult=1 m=1
XR2 v[1] v[2] gnd sky130_fd_pr__res_xhigh_po_2p85 L=0.9742 mult=1 m=1
XR4 v[3] v[4] gnd sky130_fd_pr__res_xhigh_po_2p85 L=0.9742 mult=1 m=1
XR6 v[5] v[6] gnd sky130_fd_pr__res_xhigh_po_2p85 L=0.9742 mult=1 m=1
XR3 v[2] v[3] gnd sky130_fd_pr__res_xhigh_po_2p85 L=1.0438 mult=1 m=1
XR5 v[4] v[5] gnd sky130_fd_pr__res_xhigh_po_2p85 L=1.0438 mult=1 m=1
XR9 v[8] v[9] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.5164 mult=1 m=1
XR14 v[13] v[14] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.5508 mult=1 m=1
XR15 v[14] v[15] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.5508 mult=1 m=1
XR16 v[15] v[16] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.5508 mult=1 m=1
XR18 v[17] v[18] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.5508 mult=1 m=1
XR19 v[18] v[19] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.5853 mult=1 m=1
XR20 v[19] v[20] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.5853 mult=1 m=1
XR21 v[20] v[21] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.5853 mult=1 m=1
XR22 v[21] v[22] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.5853 mult=1 m=1
XR24 v[23] v[24] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.6197 mult=1 m=1
XR25 v[24] v[25] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.6197 mult=1 m=1
XR26 v[25] v[26] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.6197 mult=1 m=1
XR27 v[26] v[27] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.6197 mult=1 m=1
XR29 v[28] v[29] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.6541 mult=1 m=1
XR30 v[29] v[30] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.6541 mult=1 m=1
XR32 v[31] v[32] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.6541 mult=1 m=1
XR33 v[32] v[33] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.6885 mult=1 m=1
XR35 v[34] v[35] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.6885 mult=1 m=1
XR38 v[37] v[38] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.7574 mult=1 m=1
XR39 v[38] v[39] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.7574 mult=1 m=1
XR42 v[41] v[42] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.7918 mult=1 m=1
XR45 v[44] v[45] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.8607 mult=1 m=1
XR47 v[46] v[47] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.8951 mult=1 m=1
XR48 v[47] v[48] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.9295 mult=1 m=1
XR49 v[48] v[49] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.964 mult=1 m=1
XR50 v[49] v[50] gnd sky130_fd_pr__res_xhigh_po_1p41 L=0.964 mult=1 m=1
XR52 v[51] v[52] gnd sky130_fd_pr__res_xhigh_po_0p69 L=0.5054 mult=1 m=1
XR54 v[53] v[54] gnd sky130_fd_pr__res_xhigh_po_0p69 L=0.5391 mult=1 m=1
XR62 v[61] v[62] gnd sky130_fd_pr__res_xhigh_po_0p69 L=0.8424 mult=1 m=1
XR63 v[62] v[63] gnd sky130_fd_pr__res_xhigh_po_0p69 L=0.8929 mult=1 m=1
.ends


* expanding   symbol:  vselector_6b_2v_stage_1.sym # of pins=4
** sym_path: xschem/vselector_6b_2v_stage_1.sym
** sch_path: xschem/vselector_6b_2v_stage_1.sch
.subckt vselector_6b_2v_stage_1 vin[0] vin[1] vin[2] vin[3] vin[4] vin[5] vin[6] vin[7] vin[8]
+ vin[9] vin[10] vin[11] vin[12] vin[13] vin[14] vin[15] vin[16] vin[17] vin[18] vin[19] vin[20] vin[21]
+ vin[22] vin[23] vin[24] vin[25] vin[26] vin[27] vin[28] vin[29] vin[30] vin[31] vin[32] vin[33] vin[34]
+ vin[35] vin[36] vin[37] vin[38] vin[39] vin[40] vin[41] vin[42] vin[43] vin[44] vin[45] vin[46] vin[47]
+ vin[48] dec[0] dec[1] dec[2] vout[0] vout[1] vout[2] vout[3] vout[4] vout[5] vout[6] vout[7] vout[8]
+ vout[9] vout[10] vout[11] vout[12] vout[13] vout[14] vout[15] vout[16] VNB
*.ipin
*+ vin[0],vin[1],vin[2],vin[3],vin[4],vin[5],vin[6],vin[7],vin[8],vin[9],vin[10],vin[11],vin[12],vin[13],vin[14],vin[15],vin[16],vin[17],vin[18],vin[19],vin[20],vin[21],vin[22],vin[23],vin[24],vin[25],vin[26],vin[27],vin[28],vin[29],vin[30],vin[31],vin[32],vin[33],vin[34],vin[35],vin[36],vin[37],vin[38],vin[39],vin[40],vin[41],vin[42],vin[43],vin[44],vin[45],vin[46],vin[47],vin[48]
*.opin
*+ vout[0],vout[1],vout[2],vout[3],vout[4],vout[5],vout[6],vout[7],vout[8],vout[9],vout[10],vout[11],vout[12],vout[13],vout[14],vout[15],vout[16]
*.ipin VNB
*.ipin dec[0],dec[1],dec[2]
x1 vin[0] vin[1] vin[2] vin[3] vin[4] vin[5] vin[6] vin[7] vin[8] vin[9] vin[10] vin[11] vin[12]
+ vin[13] vin[14] vin[15] vin[16] dec[0] vout[0] vout[1] vout[2] vout[3] vout[4] vout[5] vout[6] vout[7]
+ vout[8] vout[9] vout[10] vout[11] vout[12] vout[13] vout[14] vout[15] vout[16] VNB vselector_16b
x2 vin[16] vin[17] vin[18] vin[19] vin[20] vin[21] vin[22] vin[23] vin[24] vin[25] vin[26] vin[27]
+ vin[28] vin[29] vin[30] vin[31] vin[32] dec[1] vout[0] vout[1] vout[2] vout[3] vout[4] vout[5] vout[6]
+ vout[7] vout[8] vout[9] vout[10] vout[11] vout[12] vout[13] vout[14] vout[15] vout[16] VNB vselector_16b
x3 vin[32] vin[33] vin[34] vin[35] vin[36] vin[37] vin[38] vin[39] vin[40] vin[41] vin[42] vin[43]
+ vin[44] vin[45] vin[46] vin[47] vin[48] dec[2] vout[0] vout[1] vout[2] vout[3] vout[4] vout[5] vout[6]
+ vout[7] vout[8] vout[9] vout[10] vout[11] vout[12] vout[13] vout[14] vout[15] vout[16] VNB vselector_16b
.ends


* expanding   symbol:  vselector_6b_2v_stage_2.sym # of pins=4
** sym_path: xschem/vselector_6b_2v_stage_2.sym
** sch_path: xschem/vselector_6b_2v_stage_2.sch
.subckt vselector_6b_2v_stage_2 vin[0] vin[1] vin[2] vin[3] vin[4] vin[5] vin[6] vin[7] vin[8]
+ vin[9] vin[10] vin[11] vin[12] vin[13] vin[14] vin[15] vin[16] dec[0] dec[1] dec[2] dec[3] vout[0] vout[1]
+ vout[2] vout[3] vout[4] VNB
*.ipin
*+ vin[0],vin[1],vin[2],vin[3],vin[4],vin[5],vin[6],vin[7],vin[8],vin[9],vin[10],vin[11],vin[12],vin[13],vin[14],vin[15],vin[16]
*.opin vout[0],vout[1],vout[2],vout[3],vout[4]
*.ipin VNB
*.ipin dec[0],dec[1],dec[2],dec[3]
x1 vin[0] vin[1] vin[2] vin[3] vin[4] dec[0] vout[0] vout[1] vout[2] vout[3] vout[4] VNB
+ vselector_4b
x2 vin[4] vin[5] vin[6] vin[7] vin[8] dec[1] vout[0] vout[1] vout[2] vout[3] vout[4] VNB
+ vselector_4b
x3 vin[8] vin[9] vin[10] vin[11] vin[12] dec[2] vout[0] vout[1] vout[2] vout[3] vout[4] VNB
+ vselector_4b
x4 vin[12] vin[13] vin[14] vin[15] vin[16] dec[3] vout[0] vout[1] vout[2] vout[3] vout[4] VNB
+ vselector_4b
.ends


* expanding   symbol:  vselector_6b_2v_stage_3.sym # of pins=5
** sym_path: xschem/vselector_6b_2v_stage_3.sym
** sch_path: xschem/vselector_6b_2v_stage_3.sch
.subckt vselector_6b_2v_stage_3 vin[0] vin[1] vin[2] vin[3] vin[4] dec[0] dec[1] dec[2] dec[3] VH VL
+ VNB
*.ipin vin[0],vin[1],vin[2],vin[3],vin[4]
*.opin VH
*.ipin VNB
*.ipin dec[0],dec[1],dec[2],dec[3]
*.opin VL
x1 vin[0] vin[1] dec[0] VH VL VNB vselector_1b
x2 vin[1] vin[2] dec[1] VH VL VNB vselector_1b
x3 vin[2] vin[3] dec[2] VH VL VNB vselector_1b
x4 vin[3] vin[4] dec[3] VH VL VNB vselector_1b
.ends


* expanding   symbol:  switch_pmos_1g_9o.sym # of pins=4
** sym_path: xschem/switch_pmos_1g_9o.sym
** sch_path: xschem/switch_pmos_1g_9o.sch
.subckt switch_pmos_1g_9o vin[0] vin[1] vin[2] vin[3] vin[4] vin[5] vin[6] vin[7] vin[8] DIN vout[0]
+ vout[1] vout[2] vout[3] vout[4] vout[5] vout[6] vout[7] vout[8] VPB
*.ipin vin[0],vin[1],vin[2],vin[3],vin[4],vin[5],vin[6],vin[7],vin[8]
*.opin vout[0],vout[1],vout[2],vout[3],vout[4],vout[5],vout[6],vout[7],vout[8]
*.ipin VPB
*.ipin DIN
.param wp=0.42 wn=0.42 l=0.5

XM1 vout[0] DIN vin[0] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM2 vout[1] DIN vin[1] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM3 vout[2] DIN vin[2] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM4 vout[3] DIN vin[3] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM5 vout[4] DIN vin[4] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM6 vout[5] DIN vin[5] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM7 vout[6] DIN vin[6] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM8 vout[7] DIN vin[7] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM9 vout[8] DIN vin[8] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  switch_pmos_1g_5o.sym # of pins=4
** sym_path: xschem/switch_pmos_1g_5o.sym
** sch_path: xschem/switch_pmos_1g_5o.sch
.subckt switch_pmos_1g_5o vin[0] vin[1] vin[2] vin[3] vin[4] DIN vout[0] vout[1] vout[2] vout[3]
+ vout[4] VPB
*.ipin vin[0],vin[1],vin[2],vin[3],vin[4]
*.opin vout[0],vout[1],vout[2],vout[3],vout[4]
*.ipin VPB
*.ipin DIN
.param wp=0.42 wn=0.42 l=0.5

XM1 vout[0] DIN vin[0] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM2 vout[1] DIN vin[1] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM3 vout[2] DIN vin[2] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM4 vout[3] DIN vin[3] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM5 vout[4] DIN vin[4] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  switch_pmos_1g_3o.sym # of pins=4
** sym_path: xschem/switch_pmos_1g_3o.sym
** sch_path: xschem/switch_pmos_1g_3o.sch
.subckt switch_pmos_1g_3o vin[0] vin[1] vin[2] DIN vout[0] vout[1] vout[2] VPB
*.ipin vin[0],vin[1],vin[2]
*.opin vout[0],vout[1],vout[2]
*.ipin VPB
*.ipin DIN
.param wp=0.42 wn=0.42 l=0.5

XM1 vout[0] DIN vin[0] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM2 vout[1] DIN vin[1] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM3 vout[2] DIN vin[2] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  switch_pmos_1g_2o.sym # of pins=5
** sym_path: xschem/switch_pmos_1g_2o.sym
** sch_path: xschem/switch_pmos_1g_2o.sch
.subckt switch_pmos_1g_2o vin[0] vin[1] DIN VH VL VPB
*.ipin vin[0],vin[1]
*.opin VH
*.ipin VPB
*.ipin DIN
*.opin VL
.param wp=0.42 wn=0.42 l=0.5

XM1 VL DIN vin[0] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM2 VH DIN vin[1] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  vselector_6b_1v_stage_1_pmos.sym # of pins=4
** sym_path: xschem/vselector_6b_1v_stage_1_pmos.sym
** sch_path: xschem/vselector_6b_1v_stage_1_pmos.sch
.subckt vselector_6b_1v_stage_1_pmos vin[0] vin[1] vin[2] vin[3] vin[4] vin[5] vin[6] vin[7] vin[8]
+ vin[9] vin[10] vin[11] vin[12] vin[13] vin[14] vin[15] vin[16] vin[17] vin[18] vin[19] vin[20] vin[21]
+ vin[22] vin[23] vin[24] vin[25] vin[26] vin[27] vin[28] vin[29] vin[30] vin[31] vin[32] vin[33] vin[34]
+ vin[35] vin[36] vin[37] vin[38] vin[39] vin[40] vin[41] vin[42] vin[43] vin[44] vin[45] vin[46] vin[47]
+ vin[48] vin[49] vin[50] vin[51] vin[52] vin[53] vin[54] vin[55] vin[56] vin[57] vin[58] vin[59] vin[60]
+ vin[61] vin[62] vin[63] dec[0] dec[1] dec[2] dec[3] vout[0] vout[1] vout[2] vout[3] vout[4] vout[5] vout[6]
+ vout[7] vout[8] vout[9] vout[10] vout[11] vout[12] vout[13] vout[14] vout[15] VPB
*.ipin
*+ vin[0],vin[1],vin[2],vin[3],vin[4],vin[5],vin[6],vin[7],vin[8],vin[9],vin[10],vin[11],vin[12],vin[13],vin[14],vin[15],vin[16],vin[17],vin[18],vin[19],vin[20],vin[21],vin[22],vin[23],vin[24],vin[25],vin[26],vin[27],vin[28],vin[29],vin[30],vin[31],vin[32],vin[33],vin[34],vin[35],vin[36],vin[37],vin[38],vin[39],vin[40],vin[41],vin[42],vin[43],vin[44],vin[45],vin[46],vin[47],vin[48],vin[49],vin[50],vin[51],vin[52],vin[53],vin[54],vin[55],vin[56],vin[57],vin[58],vin[59],vin[60],vin[61],vin[62],vin[63]
*.opin
*+ vout[0],vout[1],vout[2],vout[3],vout[4],vout[5],vout[6],vout[7],vout[8],vout[9],vout[10],vout[11],vout[12],vout[13],vout[14],vout[15]
*.ipin VPB
*.ipin dec[0],dec[1],dec[2],dec[3]
x1 vin[0] vin[1] vin[2] vin[3] vin[4] vin[5] vin[6] vin[7] vin[8] vin[9] vin[10] vin[11] vin[12]
+ vin[13] vin[14] vin[15] dec[0] vout[0] vout[1] vout[2] vout[3] vout[4] vout[5] vout[6] vout[7] vout[8]
+ vout[9] vout[10] vout[11] vout[12] vout[13] vout[14] vout[15] VPB vselector_16b_1v_pmos
x2 vin[16] vin[17] vin[18] vin[19] vin[20] vin[21] vin[22] vin[23] vin[24] vin[25] vin[26] vin[27]
+ vin[28] vin[29] vin[30] vin[31] dec[1] vout[0] vout[1] vout[2] vout[3] vout[4] vout[5] vout[6] vout[7]
+ vout[8] vout[9] vout[10] vout[11] vout[12] vout[13] vout[14] vout[15] VPB vselector_16b_1v_pmos
x3 vin[32] vin[33] vin[34] vin[35] vin[36] vin[37] vin[38] vin[39] vin[40] vin[41] vin[42] vin[43]
+ vin[44] vin[45] vin[46] vin[47] dec[2] vout[0] vout[1] vout[2] vout[3] vout[4] vout[5] vout[6] vout[7]
+ vout[8] vout[9] vout[10] vout[11] vout[12] vout[13] vout[14] vout[15] VPB vselector_16b_1v_pmos
x4 vin[48] vin[49] vin[50] vin[51] vin[52] vin[53] vin[54] vin[55] vin[56] vin[57] vin[58] vin[59]
+ vin[60] vin[61] vin[62] vin[63] dec[3] vout[0] vout[1] vout[2] vout[3] vout[4] vout[5] vout[6] vout[7]
+ vout[8] vout[9] vout[10] vout[11] vout[12] vout[13] vout[14] vout[15] VPB vselector_16b_1v_pmos
.ends


* expanding   symbol:  switch_pmos_1g_8o.sym # of pins=4
** sym_path: xschem/switch_pmos_1g_8o.sym
** sch_path: xschem/switch_pmos_1g_8o.sch
.subckt switch_pmos_1g_8o vin[0] vin[1] vin[2] vin[3] vin[4] vin[5] vin[6] vin[7] DIN vout[0]
+ vout[1] vout[2] vout[3] vout[4] vout[5] vout[6] vout[7] VPB
*.ipin vin[0],vin[1],vin[2],vin[3],vin[4],vin[5],vin[6],vin[7]
*.opin vout[0],vout[1],vout[2],vout[3],vout[4],vout[5],vout[6],vout[7]
*.ipin VPB
*.ipin DIN
.param wp=0.42 wn=0.42 l=0.5

XM1 vout[0] DIN vin[0] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM2 vout[1] DIN vin[1] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM3 vout[2] DIN vin[2] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM4 vout[3] DIN vin[3] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM5 vout[4] DIN vin[4] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM6 vout[5] DIN vin[5] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM7 vout[6] DIN vin[6] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM8 vout[7] DIN vin[7] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  switch_pmos_1g_4o.sym # of pins=4
** sym_path: xschem/switch_pmos_1g_4o.sym
** sch_path: xschem/switch_pmos_1g_4o.sch
.subckt switch_pmos_1g_4o vin[0] vin[1] vin[2] vin[3] DIN vout[0] vout[1] vout[2] vout[3] VPB
*.ipin vin[0],vin[1],vin[2],vin[3]
*.opin vout[0],vout[1],vout[2],vout[3]
*.ipin VPB
*.ipin DIN
.param wp=0.42 wn=0.42 l=0.5

XM1 vout[0] DIN vin[0] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM2 vout[1] DIN vin[1] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM3 vout[2] DIN vin[2] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM4 vout[3] DIN vin[3] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  switch_pmos_2g_1o.sym # of pins=5
** sym_path: xschem/switch_pmos_2g_1o.sym
** sch_path: xschem/switch_pmos_2g_1o.sch
.subckt switch_pmos_2g_1o vin[0] vin[1] DIN DINB VOUT VPB
*.ipin vin[0],vin[1]
*.opin VOUT
*.ipin VPB
*.ipin DIN
*.ipin DINB
.param wp=0.42 wn=0.42 l=0.5

XM1 VOUT DIN vin[0] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM2 VOUT DINB vin[1] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  seg_selector_1.sym # of pins=4
** sym_path: xschem/seg_selector_1.sym
** sch_path: xschem/seg_selector_1.sch
.subckt seg_selector_1 DIN VIN vout[0] vout[1] vout[2] vout[3] vout[4] VNB
*.opin vout[0],vout[1],vout[2],vout[3],vout[4]
*.ipin VNB
*.ipin DIN
*.ipin VIN
.param wp=0.42 wn=0.42 l=0.5

XM1 vout[0] DIN VIN VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM2 vout[1] DIN VIN VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM3 vout[2] DIN VIN VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM4 vout[3] DIN VIN VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM5 vout[4] DIN VIN VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  seg_selector_2.sym # of pins=5
** sym_path: xschem/seg_selector_2.sym
** sch_path: xschem/seg_selector_2.sch
.subckt seg_selector_2 DIN VL vin[0] vin[1] vin[2] vin[3] vout[0] vout[1] vout[2] vout[3] vout[4]
+ VNB
*.opin vout[0],vout[1],vout[2],vout[3],vout[4]
*.ipin VNB
*.ipin DIN
*.ipin vin[0],vin[1],vin[2],vin[3]
*.ipin VL
.param wp=0.42 wn=0.42 l=0.5

XM1 vout[0] DIN VL VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM2 vout[1] DIN vin[0] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM3 vout[2] DIN vin[1] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM4 vout[3] DIN vin[2] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM5 vout[4] DIN vin[3] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  seg_selector_3.sym # of pins=5
** sym_path: xschem/seg_selector_3.sym
** sch_path: xschem/seg_selector_3.sch
.subckt seg_selector_3 DINB VL vin[0] vin[1] vin[2] vout[0] vout[1] vout[2] vout[3] vout[4] VPB
*.opin vout[0],vout[1],vout[2],vout[3],vout[4]
*.ipin VPB
*.ipin DINB
*.ipin vin[0],vin[1],vin[2]
*.ipin VL
.param wp=0.42 wn=0.42 l=0.5

XM1 vout[0] DINB VL VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM2 vout[1] DINB VL VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM3 vout[2] DINB vin[0] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM4 vout[3] DINB vin[1] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM5 vout[4] DINB vin[2] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  seg_selector_4.sym # of pins=4
** sym_path: xschem/seg_selector_4.sym
** sch_path: xschem/seg_selector_4.sch
.subckt seg_selector_4 DINB VIN vout[0] vout[1] vout[2] vout[3] vout[4] VPB
*.opin vout[0],vout[1],vout[2],vout[3],vout[4]
*.ipin VPB
*.ipin DINB
*.ipin VIN
.param wp=0.42 wn=0.42 l=0.5

XM1 vout[0] DINB VIN VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM2 vout[1] DINB VIN VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM3 vout[2] DINB VIN VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM4 vout[3] DINB VIN VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM5 vout[4] DINB VIN VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  seg_selector_logic.sym # of pins=5
** sym_path: xschem/seg_selector_logic.sym
** sch_path: xschem/seg_selector_logic.sch
.subckt seg_selector_logic b[6] b[7] b[8] b[9] bb[6] bb[7] bb[8] bb[9] S[1] S[2] S[3] S[4] VDD GND
*.ipin b[6],b[7],b[8],b[9]
*.opin S[1],S[2],S[3],S[4]
*.ipin GND
*.ipin VDD
*.ipin bb[6],bb[7],bb[8],bb[9]
x1 bb[6] bb[7] bb[8] bb[9] S[1] VDD GND seg_selector_1_logic
x2 b[6] b[7] b[8] b[9] bb[6] bb[7] bb[8] bb[9] S[2] VDD GND seg_selector_2_logic
x3 b[6] b[7] b[8] b[9] bb[6] bb[7] S[3] VDD GND seg_selector_3_logic
x4 b[6] b[7] b[8] b[9] S[4] VDD GND seg_selector_4_logic
.ends


* expanding   symbol:  lvsf.sym # of pins=7
** sym_path: xschem/lvsf.sym
** sch_path: xschem/lvsf.sch
.subckt lvsf VPBIAS VNBIAS IN INB OUTP VDDH GND
*.ipin IN
*.ipin INB
*.opin OUTP
*.ipin VDDH
*.ipin GND
*.ipin VPBIAS
*.ipin VNBIAS
Vmeas net1 net2 0
.save i(vmeas)
XM13 net6 IN GND GND sky130_fd_pr__nfet_01v8 L=0.15 W=3 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM1 net3 VPBIAS VDDH VDDH sky130_fd_pr__pfet_g5v0d10v5 L=0.8 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM2 net1 VPBIAS VDDH VDDH sky130_fd_pr__pfet_g5v0d10v5 L=0.8 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM3 OUTPB OUTP net4 VDDH sky130_fd_pr__pfet_g5v0d10v5 L=0.8 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM4 OUTP OUTPB net2 VDDH sky130_fd_pr__pfet_g5v0d10v5 L=0.8 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM5 OUTPB VNBIAS n1 GND sky130_fd_pr__nfet_g5v0d10v5 L=1 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM6 OUTP VNBIAS n2 GND sky130_fd_pr__nfet_g5v0d10v5 L=1 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
Vmeas1 net3 net4 0
.save i(vmeas1)
XM7 net5 INB GND GND sky130_fd_pr__nfet_01v8 L=0.15 W=3 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
Vmeas2 n2 net5 0
.save i(vmeas2)
Vmeas3 n1 net6 0
.save i(vmeas3)
.ends


* expanding   symbol:  pull_up_down_network.sym # of pins=9
** sym_path: xschem/pull_up_down_network.sym
** sch_path: xschem/pull_up_down_network.sch
.subckt pull_up_down_network VPBIAS VNBIAS DIN V[0] V[1] V[2] VOUT VDDH GND VPB VNB
*.ipin VPBIAS
*.ipin VNBIAS
*.ipin DIN
*.ipin V[0],V[1],V[2]
*.opin VOUT
*.ipin VDDH
*.ipin GND
*.ipin VPB
*.ipin VNB
XM1 net2 VPBIAS VDDH VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
.param wp=0.84 wn=1 l=1

XM2 net3 V[0] net2 VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM3 net4 V[1] net3 VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM4 VOUT V[2] net4 VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM5 VOUT VNBIAS net1 VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM6 net1 DIN GND VNB sky130_fd_pr__nfet_01v8 L=0.15 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  vselector_6b_1v_stage_1.sym # of pins=4
** sym_path: xschem/vselector_6b_1v_stage_1.sym
** sch_path: xschem/vselector_6b_1v_stage_1.sch
.subckt vselector_6b_1v_stage_1 vin[0] vin[1] vin[2] vin[3] vin[4] vin[5] vin[6] vin[7] vin[8]
+ vin[9] vin[10] vin[11] vin[12] vin[13] vin[14] vin[15] vin[16] vin[17] vin[18] vin[19] vin[20] vin[21]
+ vin[22] vin[23] vin[24] vin[25] vin[26] vin[27] vin[28] vin[29] vin[30] vin[31] vin[32] vin[33] vin[34]
+ vin[35] vin[36] vin[37] vin[38] vin[39] vin[40] vin[41] vin[42] vin[43] vin[44] vin[45] vin[46] vin[47]
+ vin[48] vin[49] vin[50] vin[51] vin[52] vin[53] vin[54] vin[55] vin[56] vin[57] vin[58] vin[59] vin[60]
+ vin[61] vin[62] vin[63] dec[0] dec[1] dec[2] dec[3] vout[0] vout[1] vout[2] vout[3] vout[4] vout[5] vout[6]
+ vout[7] vout[8] vout[9] vout[10] vout[11] vout[12] vout[13] vout[14] vout[15] VNB
*.ipin
*+ vin[0],vin[1],vin[2],vin[3],vin[4],vin[5],vin[6],vin[7],vin[8],vin[9],vin[10],vin[11],vin[12],vin[13],vin[14],vin[15],vin[16],vin[17],vin[18],vin[19],vin[20],vin[21],vin[22],vin[23],vin[24],vin[25],vin[26],vin[27],vin[28],vin[29],vin[30],vin[31],vin[32],vin[33],vin[34],vin[35],vin[36],vin[37],vin[38],vin[39],vin[40],vin[41],vin[42],vin[43],vin[44],vin[45],vin[46],vin[47],vin[48],vin[49],vin[50],vin[51],vin[52],vin[53],vin[54],vin[55],vin[56],vin[57],vin[58],vin[59],vin[60],vin[61],vin[62],vin[63]
*.opin
*+ vout[0],vout[1],vout[2],vout[3],vout[4],vout[5],vout[6],vout[7],vout[8],vout[9],vout[10],vout[11],vout[12],vout[13],vout[14],vout[15]
*.ipin VNB
*.ipin dec[0],dec[1],dec[2],dec[3]
x1 vin[48] vin[49] vin[50] vin[51] vin[52] vin[53] vin[54] vin[55] vin[56] vin[57] vin[58] vin[59]
+ vin[60] vin[61] vin[62] vin[63] dec[3] vout[0] vout[1] vout[2] vout[3] vout[4] vout[5] vout[6] vout[7]
+ vout[8] vout[9] vout[10] vout[11] vout[12] vout[13] vout[14] vout[15] VNB vselector_16b_1v
x2 vin[32] vin[33] vin[34] vin[35] vin[36] vin[37] vin[38] vin[39] vin[40] vin[41] vin[42] vin[43]
+ vin[44] vin[45] vin[46] vin[47] dec[2] vout[0] vout[1] vout[2] vout[3] vout[4] vout[5] vout[6] vout[7]
+ vout[8] vout[9] vout[10] vout[11] vout[12] vout[13] vout[14] vout[15] VNB vselector_16b_1v
x3 vin[16] vin[17] vin[18] vin[19] vin[20] vin[21] vin[22] vin[23] vin[24] vin[25] vin[26] vin[27]
+ vin[28] vin[29] vin[30] vin[31] dec[1] vout[0] vout[1] vout[2] vout[3] vout[4] vout[5] vout[6] vout[7]
+ vout[8] vout[9] vout[10] vout[11] vout[12] vout[13] vout[14] vout[15] VNB vselector_16b_1v
x4 vin[0] vin[1] vin[2] vin[3] vin[4] vin[5] vin[6] vin[7] vin[8] vin[9] vin[10] vin[11] vin[12]
+ vin[13] vin[14] vin[15] dec[0] vout[0] vout[1] vout[2] vout[3] vout[4] vout[5] vout[6] vout[7] vout[8]
+ vout[9] vout[10] vout[11] vout[12] vout[13] vout[14] vout[15] VNB vselector_16b_1v
.ends


* expanding   symbol:  switch_nmos_1g_8o.sym # of pins=4
** sym_path: xschem/switch_nmos_1g_8o.sym
** sch_path: xschem/switch_nmos_1g_8o.sch
.subckt switch_nmos_1g_8o vin[0] vin[1] vin[2] vin[3] vin[4] vin[5] vin[6] vin[7] DIN vout[0]
+ vout[1] vout[2] vout[3] vout[4] vout[5] vout[6] vout[7] VNB
*.ipin vin[0],vin[1],vin[2],vin[3],vin[4],vin[5],vin[6],vin[7]
*.opin vout[0],vout[1],vout[2],vout[3],vout[4],vout[5],vout[6],vout[7]
*.ipin VNB
*.ipin DIN
.param wp=0.42 wn=0.42 l=0.5

XM1 vin[0] DIN vout[0] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM2 vin[1] DIN vout[1] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM3 vin[2] DIN vout[2] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM4 vin[3] DIN vout[3] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM5 vin[4] DIN vout[4] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM6 vin[5] DIN vout[5] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM7 vin[6] DIN vout[6] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM8 vin[7] DIN vout[7] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  switch_nmos_1g_4o.sym # of pins=4
** sym_path: xschem/switch_nmos_1g_4o.sym
** sch_path: xschem/switch_nmos_1g_4o.sch
.subckt switch_nmos_1g_4o vin[0] vin[1] vin[2] vin[3] DIN vout[0] vout[1] vout[2] vout[3] VNB
*.ipin vin[0],vin[1],vin[2],vin[3]
*.opin vout[0],vout[1],vout[2],vout[3]
*.ipin VNB
*.ipin DIN
.param wp=0.42 wn=0.42 l=0.5

XM1 vin[0] DIN vout[0] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM2 vin[1] DIN vout[1] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM3 vin[2] DIN vout[2] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM4 vin[3] DIN vout[3] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  switch_nmos_1g_2o.sym # of pins=4
** sym_path: xschem/switch_nmos_1g_2o.sym
** sch_path: xschem/switch_nmos_1g_2o.sch
.subckt switch_nmos_1g_2o vin[0] vin[1] DIN vout[0] vout[1] VNB
*.ipin vin[0],vin[1]
*.opin vout[0],vout[1]
*.ipin VNB
*.ipin DIN
.param wp=0.42 wn=0.42 l=0.5

XM2 vin[1] DIN vout[1] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM1 vin[0] DIN vout[0] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  switch_nmos_2g_2o.sym # of pins=6
** sym_path: xschem/switch_nmos_2g_2o.sym
** sch_path: xschem/switch_nmos_2g_2o.sch
.subckt switch_nmos_2g_2o vin[0] vin[1] DIN DINB VH VL VNB
*.ipin vin[0],vin[1]
*.opin VH
*.ipin VNB
*.ipin DIN
*.opin VL
*.ipin DINB
.param wp=0.42 wn=0.42 l=0.5

XM2 vin[1] DIN VH VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM1 vin[0] DINB VL VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  head.sym # of pins=4
** sym_path: xschem/head.sym
** sch_path: xschem/head.sch
.subckt head VB1 VB2 I_OUT VDDA  mv=1
*.opin I_OUT
*.ipin VB1
*.ipin VB2
*.ipin VDDA
XM5 n1 VB1 VDDA VDDA sky130_fd_pr__pfet_g5v0d10v5 L=1 W=1.8 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=mv m=mv
XM1 I_OUT VB2 n1 VDDA sky130_fd_pr__pfet_g5v0d10v5 L=1 W=1.8 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=mv m=mv
.ends


* expanding   symbol:  tail.sym # of pins=4
** sym_path: xschem/tail.sym
** sch_path: xschem/tail.sch
.subckt tail VB1 VB2 I_OUT GNDA  mv=1
*.opin I_OUT
*.ipin VB1
*.ipin VB2
*.ipin GNDA
XM1 I_OUT VB2 n1 GNDA sky130_fd_pr__nfet_g5v0d10v5 L=1 W=0.6 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=mv m=mv
XM2 n1 VB1 GNDA GNDA sky130_fd_pr__nfet_g5v0d10v5 L=1 W=0.6 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=mv m=mv
.ends


* expanding   symbol:  folded_cascode.sym # of pins=11
** sym_path: xschem/folded_cascode.sym
** sch_path: xschem/folded_cascode.sch
.subckt folded_cascode VBS1 VBS2 VB1 VB2 I_OPA I_OPB I_ONA I_ONB VOUT VDDA GNDA
*.ipin I_OPA
*.ipin I_OPB
*.ipin I_ONA
*.ipin I_ONB
*.opin VOUT
*.ipin VBS1
*.ipin VBS2
*.ipin VB1
*.ipin VB2
*.ipin VDDA
*.ipin GNDA
.param wp_sum=4.8 wn_sum=1.6 l_sum=1 m_sum=2 wp_fcm=4.8 wn_fcm=1.6 m_fcm=2

XM1 I_ONB VGP net1 net1 sky130_fd_pr__pfet_g5v0d10v5 L=1 W=4.8 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=2 m=2
XM8 VGP VB2 VGN GNDA sky130_fd_pr__nfet_g5v0d10v5 L=1 W=1.6 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=2 m=2
XM13 GNDA GNDA GNDA GNDA sky130_fd_pr__nfet_g5v0d10v5 L=1 W=1.6 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=4 m=4
XM2 I_ONA VGP net2 net2 sky130_fd_pr__pfet_g5v0d10v5 L=1 W=4.8 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=2 m=2
XM3 net7 VBS1 I_ONB net1 sky130_fd_pr__pfet_g5v0d10v5 L=1 W=4.8 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=2 m=2
XM4 net8 VBS1 I_ONA net2 sky130_fd_pr__pfet_g5v0d10v5 L=1 W=4.8 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=2 m=2
XM5 VGN VB1 VGP VDDA sky130_fd_pr__pfet_g5v0d10v5 L=1 W=4.8 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=2 m=2
XM6 B VB1 A VDDA sky130_fd_pr__pfet_g5v0d10v5 L=1 W=4.8 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=2 m=2
XM7 A VB2 B GNDA sky130_fd_pr__nfet_g5v0d10v5 L=1 W=1.6 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=2 m=2
XM10 net9 VBS2 I_OPB net3 sky130_fd_pr__nfet_g5v0d10v5 L=1 W=1.6 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=2 m=2
XM11 net10 VBS2 I_OPA net4 sky130_fd_pr__nfet_g5v0d10v5 L=1 W=1.6 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=2 m=2
XM9 I_OPB VGN net3 net3 sky130_fd_pr__nfet_g5v0d10v5 L=1 W=1.6 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=6 m=6
XM12 I_OPA VGN net4 net4 sky130_fd_pr__nfet_g5v0d10v5 L=1 W=1.6 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=6 m=6
XM14 VOUT B net6 net6 sky130_fd_pr__nfet_g5v0d10v5 L=1 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=2 m=2
XM15 VOUT A net5 net5 sky130_fd_pr__pfet_g5v0d10v5 L=1 W=6 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=2 m=2
Vmeas net3 GNDA 0
.save i(vmeas)
Vmeas1 net4 GNDA 0
.save i(vmeas1)
Vmeas2 VGN net9 0
.save i(vmeas2)
Vmeas3 B net10 0
.save i(vmeas3)
Vmeas4 VDDA net1 0
.save i(vmeas4)
Vmeas5 VDDA net2 0
.save i(vmeas5)
Vmeas6 net7 VGP 0
.save i(vmeas6)
Vmeas7 net8 A 0
.save i(vmeas7)
Vmeas8 VDDA net5 0
.save i(vmeas8)
Vmeas9 net6 GNDA 0
.save i(vmeas9)
.ends


* expanding   symbol:  diff_pair.sym # of pins=10
** sym_path: xschem/diff_pair.sym
** sch_path: xschem/diff_pair.sch
.subckt diff_pair P_IN N_IN I_OPA I_OPB I_ONA I_ONB I_HEAD I_TAIL VPB VNB  weight=1
*.opin I_OPA
*.opin I_OPB
*.ipin P_IN
*.ipin N_IN
*.opin I_ONA
*.opin I_ONB
*.ipin I_HEAD
*.ipin I_TAIL
*.ipin VPB
*.ipin VNB
XM1 I_OPA P_IN I_HEAD VPB sky130_fd_pr__pfet_g5v0d10v5 L=l_diff W=wp_diff nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=2 m=2
XM3 I_ONA P_IN I_TAIL VNB sky130_fd_pr__nfet_g5v0d10v5 L=l_diff W=wn_diff nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=2 m=2
.param wp_diff=3 wn_diff=1 l_diff=1

XM2 I_OPB N_IN I_HEAD VPB sky130_fd_pr__pfet_g5v0d10v5 L=l_diff W=wp_diff nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=2 m=2
XM4 I_ONB N_IN I_TAIL VNB sky130_fd_pr__nfet_g5v0d10v5 L=l_diff W=wn_diff nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=2 m=2
.ends


* expanding   symbol:  bias_opamp.sym # of pins=9
** sym_path: xschem/bias_opamp.sym
** sch_path: xschem/bias_opamp.sch
.subckt bias_opamp ROUT VHEAD1 VHEAD2 VTAIL1 VTAIL2 VBS1 VBS2 VDDA GNDA
*.ipin ROUT
*.opin VHEAD1
*.ipin VDDA
*.ipin GNDA
*.opin VHEAD2
*.opin VTAIL1
*.opin VTAIL2
*.opin VBS1
*.opin VBS2
.param wp_iref=1.8 wn_iref=0.6 miref=20 miref2=8 wp_bias=4.8 wn_bias=1.6 mbias=2 l=1 lref=1 lr=20
XM1 net1 VHEAD1 VDDA VDDA sky130_fd_pr__pfet_g5v0d10v5 L=1 W=1.8 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=20 m=20
XM2 VHEAD1 VHEAD2 net1 VDDA sky130_fd_pr__pfet_g5v0d10v5 L=1 W=1.8 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=20 m=20
XM7 net6 VHEAD1 VDDA VDDA sky130_fd_pr__pfet_g5v0d10v5 L=1 W=1.8 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=20 m=20
XM8 net5 VHEAD2 net6 VDDA sky130_fd_pr__pfet_g5v0d10v5 L=1 W=1.8 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=20 m=20
XM3 VHEAD2 net2 VHEAD1 VDDA sky130_fd_pr__pfet_g5v0d10v5 L=20 W=1.8 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=2 m=2
XM4 net2 net2 VHEAD2 VDDA sky130_fd_pr__pfet_g5v0d10v5 L=20 W=1.8 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=2 m=2
XM5 net3 ROUT net2 VDDA sky130_fd_pr__pfet_g5v0d10v5 L=20 W=1.8 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=2 m=2
XM6 ROUT ROUT net3 VDDA sky130_fd_pr__pfet_g5v0d10v5 L=20 W=1.8 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=2 m=2
XM13 net7 VHEAD1 VDDA VDDA sky130_fd_pr__pfet_g5v0d10v5 L=1 W=1.8 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=8 m=8
XM14 VBS2 VHEAD2 net7 VDDA sky130_fd_pr__pfet_g5v0d10v5 L=1 W=1.8 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=8 m=8
XM17 PVB PVB VDDA VDDA sky130_fd_pr__pfet_g5v0d10v5 L=1 W=4.8 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=2 m=2
XM18 VBS1 VBS1 PVB VDDA sky130_fd_pr__pfet_g5v0d10v5 L=1 W=4.8 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=2 m=2
XM11 net4 VTAIL1 GNDA GNDA sky130_fd_pr__nfet_g5v0d10v5 L=1 W=0.6 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=20 m=20
XM12 VTAIL1 VTAIL2 net4 GNDA sky130_fd_pr__nfet_g5v0d10v5 L=1 W=0.6 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=20 m=20
XM9 net5 net5 VTAIL2 GNDA sky130_fd_pr__nfet_g5v0d10v5 L=20 W=0.6 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=2 m=2
XM10 VTAIL2 net5 VTAIL1 GNDA sky130_fd_pr__nfet_g5v0d10v5 L=20 W=0.6 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=2 m=2
XM22 GNDA GNDA GNDA GNDA sky130_fd_pr__nfet_g5v0d10v5 L=1 W=0.6 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=6 m=6
XM19 net8 VTAIL1 GNDA GNDA sky130_fd_pr__nfet_g5v0d10v5 L=1 W=0.6 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=8 m=8
XM20 VBS1 VTAIL2 net8 GNDA sky130_fd_pr__nfet_g5v0d10v5 L=1 W=0.6 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=8 m=8
XM15 NVB NVB GNDA GNDA sky130_fd_pr__nfet_g5v0d10v5 L=1 W=1.6 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=2 m=2
XM16 VBS2 VBS2 NVB GNDA sky130_fd_pr__nfet_g5v0d10v5 L=1 W=1.6 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=2 m=2
XM23 GNDA GNDA GNDA GNDA sky130_fd_pr__nfet_g5v0d10v5 L=1 W=0.6 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=6 m=6
XM24 VDDA VDDA VDDA VDDA sky130_fd_pr__pfet_g5v0d10v5 L=1 W=1.8 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=8 m=8
XM25 VDDA VDDA VDDA VDDA sky130_fd_pr__pfet_g5v0d10v5 L=1 W=1.8 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=16 m=16
XM26 VDDA VDDA VDDA VDDA sky130_fd_pr__pfet_g5v0d10v5 L=1 W=1.8 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=16 m=16
XM27 GNDA GNDA GNDA GNDA sky130_fd_pr__nfet_g5v0d10v5 L=1 W=0.6 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=4 m=4
.ends


* expanding   symbol:  vselector_16b.sym # of pins=4
** sym_path: xschem/vselector_16b.sym
** sch_path: xschem/vselector_16b.sch
.subckt vselector_16b vin[0] vin[1] vin[2] vin[3] vin[4] vin[5] vin[6] vin[7] vin[8] vin[9] vin[10]
+ vin[11] vin[12] vin[13] vin[14] vin[15] vin[16] DIN vout[0] vout[1] vout[2] vout[3] vout[4] vout[5] vout[6]
+ vout[7] vout[8] vout[9] vout[10] vout[11] vout[12] vout[13] vout[14] vout[15] vout[16] VNB
*.ipin
*+ vin[0],vin[1],vin[2],vin[3],vin[4],vin[5],vin[6],vin[7],vin[8],vin[9],vin[10],vin[11],vin[12],vin[13],vin[14],vin[15],vin[16]
*.opin
*+ vout[0],vout[1],vout[2],vout[3],vout[4],vout[5],vout[6],vout[7],vout[8],vout[9],vout[10],vout[11],vout[12],vout[13],vout[14],vout[15],vout[16]
*.ipin VNB
*.ipin DIN
XM1 vout[0] DIN vin[0] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM2 vout[1] DIN vin[1] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM3 vout[2] DIN vin[2] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM4 vout[3] DIN vin[3] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM5 vout[4] DIN vin[4] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM6 vout[5] DIN vin[5] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM7 vout[6] DIN vin[6] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM8 vout[7] DIN vin[7] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM9 vout[8] DIN vin[8] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM10 vout[9] DIN vin[9] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM11 vout[10] DIN vin[10] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM12 vout[11] DIN vin[11] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM13 vout[12] DIN vin[12] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM14 vout[13] DIN vin[13] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM15 vout[14] DIN vin[14] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM16 vout[15] DIN vin[15] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM17 vout[16] DIN vin[16] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  vselector_4b.sym # of pins=4
** sym_path: xschem/vselector_4b.sym
** sch_path: xschem/vselector_4b.sch
.subckt vselector_4b vin[0] vin[1] vin[2] vin[3] vin[4] DIN vout[0] vout[1] vout[2] vout[3] vout[4]
+ VNB
*.ipin vin[0],vin[1],vin[2],vin[3],vin[4]
*.opin vout[0],vout[1],vout[2],vout[3],vout[4]
*.ipin VNB
*.ipin DIN
XM1 vout[0] DIN vin[0] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM2 vout[1] DIN vin[1] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM3 vout[2] DIN vin[2] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM4 vout[3] DIN vin[3] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM5 vout[4] DIN vin[4] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  vselector_1b.sym # of pins=5
** sym_path: xschem/vselector_1b.sym
** sch_path: xschem/vselector_1b.sch
.subckt vselector_1b vin[0] vin[1] DIN VH VL VNB
*.ipin vin[0],vin[1]
*.opin VL
*.ipin VNB
*.ipin DIN
*.opin VH
.param wp=0.42 wn=0.42 l=0.5

XM1 VL DIN vin[0] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM2 VH DIN vin[1] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  vselector_16b_1v_pmos.sym # of pins=4
** sym_path: xschem/vselector_16b_1v_pmos.sym
** sch_path: xschem/vselector_16b_1v_pmos.sch
.subckt vselector_16b_1v_pmos vin[0] vin[1] vin[2] vin[3] vin[4] vin[5] vin[6] vin[7] vin[8] vin[9]
+ vin[10] vin[11] vin[12] vin[13] vin[14] vin[15] DIN vout[0] vout[1] vout[2] vout[3] vout[4] vout[5] vout[6]
+ vout[7] vout[8] vout[9] vout[10] vout[11] vout[12] vout[13] vout[14] vout[15] VPB
*.ipin
*+ vin[0],vin[1],vin[2],vin[3],vin[4],vin[5],vin[6],vin[7],vin[8],vin[9],vin[10],vin[11],vin[12],vin[13],vin[14],vin[15]
*.opin
*+ vout[0],vout[1],vout[2],vout[3],vout[4],vout[5],vout[6],vout[7],vout[8],vout[9],vout[10],vout[11],vout[12],vout[13],vout[14],vout[15]
*.ipin VPB
*.ipin DIN
.param wp=0.42 wn=0.42 l=0.5

XM1 vout[0] DIN vin[0] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM2 vout[1] DIN vin[1] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM3 vout[2] DIN vin[2] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM4 vout[3] DIN vin[3] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM5 vout[4] DIN vin[4] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM6 vout[5] DIN vin[5] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM7 vout[6] DIN vin[6] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM8 vout[7] DIN vin[7] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM9 vout[8] DIN vin[8] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM10 vout[9] DIN vin[9] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM11 vout[10] DIN vin[10] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM12 vout[11] DIN vin[11] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM13 vout[12] DIN vin[12] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM14 vout[13] DIN vin[13] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM15 vout[14] DIN vin[14] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM16 vout[15] DIN vin[15] VPB sky130_fd_pr__pfet_g5v0d10v5 L=l W=wp nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  seg_selector_1_logic.sym # of pins=4
** sym_path: xschem/seg_selector_1_logic.sym
** sch_path: xschem/seg_selector_1_logic.sch
.subckt seg_selector_1_logic bb[6] bb[7] bb[8] bb[9] S VDD GND
*.opin S
*.ipin GND
*.ipin VDD
*.ipin bb[6],bb[7],bb[8],bb[9]
x1 bb[9] bb[8] GND GND VDD VDD net2 sky130_fd_sc_hd__nand2_1
x3 net2 net1 GND GND VDD VDD S sky130_fd_sc_hd__nor2_1
x2 bb[7] bb[6] GND GND VDD VDD net1 sky130_fd_sc_hd__nand2_1
.ends


* expanding   symbol:  seg_selector_2_logic.sym # of pins=5
** sym_path: xschem/seg_selector_2_logic.sym
** sch_path: xschem/seg_selector_2_logic.sch
.subckt seg_selector_2_logic b[6] b[7] b[8] b[9] bb[6] bb[7] bb[8] bb[9] S VDD GND
*.ipin b[6],b[7],b[8],b[9]
*.opin S
*.ipin GND
*.ipin VDD
*.ipin bb[6],bb[7],bb[8],bb[9]
x1 bb[9] b[6] GND GND VDD VDD n1 sky130_fd_sc_hd__nand2_1
x2 bb[9] b[7] GND GND VDD VDD n2 sky130_fd_sc_hd__nand2_1
x3 b[9] bb[8] GND GND VDD VDD n3 sky130_fd_sc_hd__nand2_1
x5 b[8] bb[7] bb[6] GND GND VDD VDD n4 sky130_fd_sc_hd__nand3_1
x4 n4 n3 n2 n1 GND GND VDD VDD S sky130_fd_sc_hd__nand4_1
.ends


* expanding   symbol:  seg_selector_3_logic.sym # of pins=5
** sym_path: xschem/seg_selector_3_logic.sym
** sch_path: xschem/seg_selector_3_logic.sch
.subckt seg_selector_3_logic b[6] b[7] b[8] b[9] bb[6] bb[7] S VDD GND
*.opin S
*.ipin GND
*.ipin VDD
*.ipin b[6],b[7],b[8],b[9]
*.ipin bb[6],bb[7]
x2 b[9] b[8] b[7] bb[6] GND GND VDD VDD net1 sky130_fd_sc_hd__nand4_1
x1 b[9] b[8] bb[7] b[6] GND GND VDD VDD net2 sky130_fd_sc_hd__nand4_1
x3 net2 net1 GND GND VDD VDD S sky130_fd_sc_hd__nand2_1
.ends


* expanding   symbol:  seg_selector_4_logic.sym # of pins=4
** sym_path: xschem/seg_selector_4_logic.sym
** sch_path: xschem/seg_selector_4_logic.sch
.subckt seg_selector_4_logic b[6] b[7] b[8] b[9] S VDD GND
*.opin S
*.ipin GND
*.ipin VDD
*.ipin b[6],b[7],b[8],b[9]
x1 b[9] b[8] GND GND VDD VDD net1 sky130_fd_sc_hd__nand2_1
x2 b[7] b[6] GND GND VDD VDD net2 sky130_fd_sc_hd__nand2_1
x3 net1 net2 GND GND VDD VDD S sky130_fd_sc_hd__nor2_1
.ends


* expanding   symbol:  vselector_16b_1v.sym # of pins=4
** sym_path: xschem/vselector_16b_1v.sym
** sch_path: xschem/vselector_16b_1v.sch
.subckt vselector_16b_1v vin[0] vin[1] vin[2] vin[3] vin[4] vin[5] vin[6] vin[7] vin[8] vin[9]
+ vin[10] vin[11] vin[12] vin[13] vin[14] vin[15] DIN vout[0] vout[1] vout[2] vout[3] vout[4] vout[5] vout[6]
+ vout[7] vout[8] vout[9] vout[10] vout[11] vout[12] vout[13] vout[14] vout[15] VNB
*.ipin
*+ vin[0],vin[1],vin[2],vin[3],vin[4],vin[5],vin[6],vin[7],vin[8],vin[9],vin[10],vin[11],vin[12],vin[13],vin[14],vin[15]
*.opin
*+ vout[0],vout[1],vout[2],vout[3],vout[4],vout[5],vout[6],vout[7],vout[8],vout[9],vout[10],vout[11],vout[12],vout[13],vout[14],vout[15]
*.ipin VNB
*.ipin DIN
.param wp=0.42 wn=0.42 l=0.5

XM1 vout[0] DIN vin[0] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM2 vout[1] DIN vin[1] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM3 vout[2] DIN vin[2] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM4 vout[3] DIN vin[3] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM5 vout[4] DIN vin[4] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM6 vout[5] DIN vin[5] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM7 vout[6] DIN vin[6] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM8 vout[7] DIN vin[7] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM9 vout[8] DIN vin[8] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM10 vout[9] DIN vin[9] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM11 vout[10] DIN vin[10] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM12 vout[11] DIN vin[11] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM13 vout[12] DIN vin[12] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM14 vout[13] DIN vin[13] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM15 vout[14] DIN vin[14] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM16 vout[15] DIN vin[15] VNB sky130_fd_pr__nfet_g5v0d10v5 L=l W=wn nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
.ends

.end
