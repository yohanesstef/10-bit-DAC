v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {seg_selector_logic.sym} 370 -390 0 0 {name=x5}
C {devices/lab_pin.sym} 520 -420 0 1 {name=p7 sig_type=std_logic lab=S[1:4]}
C {devices/lab_pin.sym} 220 -420 0 0 {name=p26 sig_type=std_logic lab=b[6:9]}
C {devices/lab_pin.sym} 220 -400 0 0 {name=p27 sig_type=std_logic lab=bb[6:9]}
C {devices/lab_pin.sym} 220 -380 0 0 {name=p28 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 220 -360 0 0 {name=p29 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 520 -400 0 1 {name=p33 sig_type=std_logic lab=SB[1:4]}
C {logic_shift_seg2.sym} 370 -290 0 0 {name=x23}
C {devices/lab_pin.sym} 220 -300 0 0 {name=p137 sig_type=std_logic lab=db[6:8]}
C {devices/lab_pin.sym} 220 -320 0 0 {name=p138 sig_type=std_logic lab=d[6:9]}
C {devices/lab_pin.sym} 220 -280 0 0 {name=p139 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 220 -260 0 0 {name=p140 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} 520 -320 0 1 {name=p141 sig_type=std_logic lab=DS[8:9]}
C {devices/lab_pin.sym} 520 -300 0 1 {name=p174 sig_type=std_logic lab=DSB[8:9]}
