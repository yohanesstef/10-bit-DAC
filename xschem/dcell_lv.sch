v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {seg_selector_logic.sym} 370 -390 0 0 {name=x5}
C {devices/lab_pin.sym} 520 -420 0 1 {name=p7 sig_type=std_logic lab=S[1:4]}
C {devices/lab_pin.sym} 220 -420 0 0 {name=p26 sig_type=std_logic lab=b[6:9]}
C {devices/lab_pin.sym} 220 -400 0 0 {name=p27 sig_type=std_logic lab=bb[6:9]}
C {devices/lab_pin.sym} 220 -380 0 0 {name=p28 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 220 -360 0 0 {name=p29 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 520 -400 0 1 {name=p33 sig_type=std_logic lab=SB[1:4]}
C {logic_shift_seg2.sym} 370 -290 0 0 {name=x23}
C {devices/lab_pin.sym} 220 -300 0 0 {name=p137 sig_type=std_logic lab=bb[6:8]}
C {devices/lab_pin.sym} 220 -280 0 0 {name=p139 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 220 -260 0 0 {name=p140 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} 520 -320 0 1 {name=p141 sig_type=std_logic lab=DS[8:9]}
C {devices/lab_pin.sym} 520 -300 0 1 {name=p174 sig_type=std_logic lab=DSB[8:9]}
C {devices/ipin.sym} 750 -240 0 0 {name=p30 lab=GND}
C {devices/ipin.sym} 750 -260 0 0 {name=p31 lab=VDD}
C {devices/ipin.sym} 740 -500 0 0 {name=p122 lab=b[6:9]}
C {devices/opin.sym} 700 -410 0 0 {name=p1 lab=DS[8:9]}
C {devices/opin.sym} 700 -390 0 0 {name=p2 lab=DSB[8:9]}
C {devices/opin.sym} 700 -450 0 0 {name=p6 lab=S[1:4]}
C {devices/opin.sym} 700 -430 0 0 {name=p4 lab=SB[1:4]}
C {devices/ipin.sym} 740 -480 0 0 {name=p3 lab=bb[6:9]}
C {devices/lab_pin.sym} 220 -320 0 0 {name=p5 sig_type=std_logic lab=b[6:9]}
