v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/title.sym} 160 -30 0 0 {name=l3 author="Yohanes Stefanus"}
C {devices/ipin.sym} 80 -230 0 0 {name=p39 lab=IN[0:3]}
C {devices/opin.sym} 60 -210 0 0 {name=p41 lab=OUT[0:3]}
C {devices/ipin.sym} 80 -190 0 0 {name=p42 lab=VDDH}
C {devices/ipin.sym} 80 -170 0 0 {name=p43 lab=GND}
C {devices/lab_pin.sym} 430 -350 0 1 {name=p3 sig_type=std_logic lab=OUT[0]}
C {devices/lab_pin.sym} 430 -290 0 1 {name=p5 sig_type=std_logic lab=OUT[1]}
C {devices/lab_pin.sym} 430 -230 0 1 {name=p6 sig_type=std_logic lab=OUT[2]}
C {devices/lab_pin.sym} 430 -170 0 1 {name=p7 sig_type=std_logic lab=OUT[3]}
C {devices/lab_pin.sym} 350 -350 0 0 {name=p10 sig_type=std_logic lab=IN[0]}
C {devices/lab_pin.sym} 350 -290 0 0 {name=p13 sig_type=std_logic lab=IN[1]}
C {devices/lab_pin.sym} 350 -230 0 0 {name=p16 sig_type=std_logic lab=IN[2]}
C {devices/lab_pin.sym} 350 -170 0 0 {name=p19 sig_type=std_logic lab=IN[3]}
C {sky130_stdcells/inv_1.sym} 390 -350 0 0 {name=x1 VGND=GND VNB=GND VPB=VDDH VPWR=VDDH prefix=sky130_fd_sc_hvl__ }
C {sky130_stdcells/inv_1.sym} 390 -290 0 0 {name=x2 VGND=GND VNB=GND VPB=VDDH VPWR=VDDH prefix=sky130_fd_sc_hvl__ }
C {sky130_stdcells/inv_1.sym} 390 -230 0 0 {name=x3 VGND=GND VNB=GND VPB=VDDH VPWR=VDDH prefix=sky130_fd_sc_hvl__ }
C {sky130_stdcells/inv_1.sym} 390 -170 0 0 {name=x4 VGND=GND VNB=GND VPB=VDDH VPWR=VDDH prefix=sky130_fd_sc_hvl__ }
