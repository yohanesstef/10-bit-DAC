v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/title.sym} 160 -30 0 0 {name=l3 author="Yohanes Stefanus"}
C {inv_hvl.sym} 390 -190 0 0 {name=x1 m=1}
C {inv_hvl.sym} 390 -260 0 0 {name=x2 m=1}
C {inv_hvl.sym} 390 -330 0 0 {name=x3 m=1}
C {inv_hvl.sym} 390 -400 0 0 {name=x4 m=1}
C {devices/ipin.sym} 80 -230 0 0 {name=p39 lab=IN[0:3]}
C {devices/opin.sym} 60 -210 0 0 {name=p41 lab=OUT[0:3]}
C {devices/ipin.sym} 80 -190 0 0 {name=p42 lab=VDDH}
C {devices/ipin.sym} 80 -170 0 0 {name=p43 lab=GND}
C {devices/lab_pin.sym} 540 -420 0 1 {name=p3 sig_type=std_logic lab=OUT[0]}
C {devices/lab_pin.sym} 540 -350 0 1 {name=p5 sig_type=std_logic lab=OUT[1]}
C {devices/lab_pin.sym} 540 -280 0 1 {name=p6 sig_type=std_logic lab=OUT[2]}
C {devices/lab_pin.sym} 540 -210 0 1 {name=p7 sig_type=std_logic lab=OUT[3]}
C {devices/lab_pin.sym} 240 -380 0 0 {name=p8 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 240 -400 0 0 {name=p9 sig_type=std_logic lab=VDDH}
C {devices/lab_pin.sym} 240 -420 0 0 {name=p10 sig_type=std_logic lab=IN[0]}
C {devices/lab_pin.sym} 240 -310 0 0 {name=p11 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 240 -330 0 0 {name=p12 sig_type=std_logic lab=VDDH}
C {devices/lab_pin.sym} 240 -350 0 0 {name=p13 sig_type=std_logic lab=IN[1]}
C {devices/lab_pin.sym} 240 -240 0 0 {name=p14 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 240 -260 0 0 {name=p15 sig_type=std_logic lab=VDDH}
C {devices/lab_pin.sym} 240 -280 0 0 {name=p16 sig_type=std_logic lab=IN[2]}
C {devices/lab_pin.sym} 240 -170 0 0 {name=p17 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 240 -190 0 0 {name=p18 sig_type=std_logic lab=VDDH}
C {devices/lab_pin.sym} 240 -210 0 0 {name=p19 sig_type=std_logic lab=IN[3]}
