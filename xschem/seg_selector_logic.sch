v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/title.sym} 160 -40 0 0 {name=l1 author="Yohanes Stefanus"}
C {devices/ipin.sym} 70 -230 0 0 {name=p39 lab=b[6:9]}
C {devices/opin.sym} 50 -210 0 0 {name=p41 lab=VOUT[0:3]}
C {devices/ipin.sym} 70 -170 0 0 {name=p42 lab=VDDH}
C {devices/ipin.sym} 70 -150 0 0 {name=p43 lab=GND}
C {devices/lab_pin.sym} 260 -240 0 0 {name=p46 sig_type=std_logic lab=b[0]}
C {devices/lab_pin.sym} 260 -170 0 0 {name=p47 sig_type=std_logic lab=b[1]}
C {devices/lab_pin.sym} 560 -240 0 1 {name=p48 sig_type=std_logic lab=bb[0]}
C {devices/lab_pin.sym} 560 -170 0 1 {name=p49 sig_type=std_logic lab=bb[1]}
C {devices/lab_pin.sym} 260 -200 0 0 {name=p51 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 260 -130 0 0 {name=p53 sig_type=std_logic lab=GND}
C {inv.sym} 410 -220 0 0 {name=x5}
C {inv.sym} 410 -150 0 0 {name=x10}
C {devices/lab_pin.sym} 260 -220 0 0 {name=p50 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 260 -150 0 0 {name=p52 sig_type=std_logic lab=VDD}
C {devices/ipin.sym} 70 -190 0 0 {name=p62 lab=VDD}
C {nand.sym} 410 -420 0 0 {name=x1}
C {nand.sym} 410 -330 0 0 {name=x2}
C {devices/lab_pin.sym} 260 -320 0 0 {name=p3 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 260 -300 0 0 {name=p4 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 260 -410 0 0 {name=p5 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 260 -390 0 0 {name=p6 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 260 -430 0 0 {name=p9 sig_type=std_logic lab=b[7]}
C {devices/lab_pin.sym} 260 -450 0 0 {name=p10 sig_type=std_logic lab=b[6]}
