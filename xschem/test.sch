v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {top_digital.sym} 340 -190 0 0 {name=x1}
C {devices/ipin.sym} 190 -120 0 0 {name=p30 lab=GND}
C {devices/ipin.sym} 190 -160 0 0 {name=p31 lab=VDD}
