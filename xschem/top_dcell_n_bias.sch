v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {top_digital.sym} 780 -450 0 0 {name=x1}
C {bias_lvsf.sym} 780 -310 0 0 {name=x2}
C {devices/lab_pin.sym} 630 -400 0 0 {name=p11 sig_type=std_logic lab=vddh}
C {devices/lab_pin.sym} 630 -380 0 0 {name=p12 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} 630 -500 0 0 {name=p13 sig_type=std_logic lab=VBPLV}
C {devices/lab_pin.sym} 630 -480 0 0 {name=p1 sig_type=std_logic lab=VBNLV}
C {devices/lab_pin.sym} 630 -460 0 0 {name=p3 sig_type=std_logic lab=VBPDEC}
C {devices/lab_pin.sym} 630 -440 0 0 {name=p4 sig_type=std_logic lab=VBNDEC}
C {devices/lab_pin.sym} 630 -420 0 0 {name=p5 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 630 -520 0 0 {name=p6 sig_type=std_logic lab=d[0..9]}
C {devices/lab_pin.sym} 930 -520 0 1 {name=p7 sig_type=std_logic lab=b[0..6]}
C {devices/lab_pin.sym} 930 -500 0 1 {name=p8 sig_type=std_logic lab=bb[0..6]}
C {devices/lab_pin.sym} 930 -480 0 1 {name=p15 sig_type=std_logic lab=dec0[0:3]}
C {devices/lab_pin.sym} 930 -460 0 1 {name=p16 sig_type=std_logic lab=dec1[0:3]}
C {devices/lab_pin.sym} 930 -440 0 1 {name=p24 sig_type=std_logic lab=dec2[0:3]}
C {devices/lab_pin.sym} 930 -420 0 1 {name=p31 sig_type=std_logic lab=dec2b[0:3]}
C {devices/lab_pin.sym} 930 -400 0 1 {name=p32 sig_type=std_logic lab=SH[1:4]}
C {devices/lab_pin.sym} 930 -340 0 1 {name=p2 sig_type=std_logic lab=VBPLV}
C {devices/lab_pin.sym} 930 -320 0 1 {name=p9 sig_type=std_logic lab=VBNLV}
C {devices/lab_pin.sym} 930 -300 0 1 {name=p10 sig_type=std_logic lab=VBPDEC}
C {devices/lab_pin.sym} 930 -280 0 1 {name=p14 sig_type=std_logic lab=VBNDEC}
C {devices/lab_pin.sym} 630 -340 0 0 {name=p19 sig_type=std_logic lab=ROUT}
C {devices/lab_pin.sym} 630 -320 0 0 {name=p17 sig_type=std_logic lab=VDDH}
C {devices/lab_pin.sym} 630 -300 0 0 {name=p18 sig_type=std_logic lab=GND}
C {devices/ipin.sym} 210 -430 0 0 {name=p30 lab=GND}
C {devices/ipin.sym} 210 -470 0 0 {name=p20 lab=VDD}
C {devices/ipin.sym} 210 -750 0 0 {name=p76 lab=VBPLV}
C {devices/ipin.sym} 210 -730 0 0 {name=p77 lab=VBNLV}
C {devices/ipin.sym} 210 -450 0 0 {name=p78 lab=VDDH}
C {devices/ipin.sym} 210 -710 0 0 {name=p120 lab=VBPDEC}
C {devices/ipin.sym} 210 -690 0 0 {name=p121 lab=VBNDEC}
C {devices/ipin.sym} 210 -770 0 0 {name=p122 lab=DIN[0..9]}
C {devices/opin.sym} 190 -660 0 0 {name=p123 lab=b[0:6]}
C {devices/opin.sym} 190 -640 0 0 {name=p124 lab=bb[0:6]}
C {devices/opin.sym} 190 -600 0 0 {name=p21 lab=dec0[0:3]}
C {devices/opin.sym} 190 -580 0 0 {name=p22 lab=dec1[0:3]}
C {devices/opin.sym} 190 -560 0 0 {name=p23 lab=dec2[0:3]}
C {devices/opin.sym} 190 -540 0 0 {name=p25 lab=dec2b[0:3]}
C {devices/opin.sym} 190 -510 0 0 {name=p26 lab=SH[1:4]}
