v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {top_digital.sym} 400 -240 0 0 {name=x1}
C {top_segment_1.sym} 890 -340 0 0 {name=x2}
