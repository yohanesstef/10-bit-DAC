v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {logic_shift_seg2.sym} 300 -100 0 0 {name=x1}
