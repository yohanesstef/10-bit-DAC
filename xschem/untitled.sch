v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {sky130_stdcells/and2_1.sym} 170 -110 0 0 {name=x1 VGND=GND VNB=GND VPB=VDDH VPWR=VDDH prefix=sky130_fd_sc_hvl__ }
C {devices/ipin.sym} 110 -130 0 0 {name=p1 lab=A}
C {devices/ipin.sym} 110 -90 0 0 {name=p2 lab=B}
C {devices/ipin.sym} 230 -110 0 1 {name=p3 lab=X}
