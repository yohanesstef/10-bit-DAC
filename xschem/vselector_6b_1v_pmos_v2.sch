v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} 110 -240 0 0 {name=p5 lab=VIN[0:63]}
C {devices/opin.sym} 90 -160 0 0 {name=p6 lab=VOUT}
C {devices/title.sym} 160 -40 0 0 {name=l1 author="Yohanes Stefanus"}
C {devices/ipin.sym} 110 -140 0 0 {name=p8 lab=VPB}
C {devices/ipin.sym} 110 -220 0 0 {name=p12 lab=DEC0[0:3]}
C {devices/lab_pin.sym} 540 -230 1 0 {name=p2 sig_type=std_logic lab=v1[0:15]}
C {devices/lab_pin.sym} 240 -230 0 0 {name=p10 sig_type=std_logic lab=VIN[0:63]}
C {devices/lab_pin.sym} 240 -210 0 0 {name=p11 sig_type=std_logic lab=DEC0[0:3]}
C {devices/lab_pin.sym} 240 -190 0 0 {name=p14 sig_type=std_logic lab=VPB}
C {vselector_6b_1v_stage_1_pmos.sym} 390 -210 0 0 {name=x1}
C {vselector_6b_1v_stage_2_pmos.sym} 800 -210 0 0 {name=x2}
C {devices/lab_pin.sym} 650 -230 1 0 {name=p3 sig_type=std_logic lab=v1[0:15]}
C {devices/lab_pin.sym} 650 -210 0 0 {name=p4 sig_type=std_logic lab=DEC1[0:3]}
C {devices/lab_pin.sym} 650 -190 0 0 {name=p7 sig_type=std_logic lab=VPB}
C {devices/lab_pin.sym} 950 -230 1 0 {name=p9 sig_type=std_logic lab=v2[0:3]}
C {devices/lab_pin.sym} 1080 -210 0 0 {name=p15 sig_type=std_logic lab=DEC2[0:3]}
C {devices/lab_pin.sym} 1080 -190 0 0 {name=p16 sig_type=std_logic lab=VPB}
C {devices/lab_pin.sym} 1380 -230 1 0 {name=p17 sig_type=std_logic lab=VOUT}
C {devices/lab_pin.sym} 1080 -230 1 0 {name=p13 sig_type=std_logic lab=v2[0:3]}
C {vselector_6b_1v_stage_3_pmos.sym} 1230 -210 0 0 {name=x3}
C {devices/ipin.sym} 110 -200 0 0 {name=p1 lab=DEC1[0:3]}
C {devices/ipin.sym} 110 -180 0 0 {name=p18 lab=DEC2[0:3]}
