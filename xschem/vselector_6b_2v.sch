v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} 120 -260 0 0 {name=p5 lab=vin[0:52]}
C {devices/opin.sym} 100 -170 0 0 {name=p6 lab=VH}
C {devices/title.sym} 160 -40 0 0 {name=l1 author="Yohanes Stefanus"}
C {devices/ipin.sym} 120 -120 0 0 {name=p7 lab=VPB}
C {devices/ipin.sym} 120 -100 0 0 {name=p8 lab=VNB}
C {devices/ipin.sym} 120 -240 0 0 {name=p12 lab=dec0[0:4]}
C {devices/opin.sym} 100 -150 0 0 {name=p50 lab=VL}
C {devices/ipin.sym} 120 -220 0 0 {name=p1 lab=dec1[0:4]}
C {devices/ipin.sym} 120 -200 0 0 {name=p35 lab=dec2[0:4]}
C {devices/param.sym} 0 -530 0 0 {name=s1 value="
+wp=0.42
+wn=0.42
+l=0.5
"}
C {vselector_6b_2v_stage_1.sym} 420 -240 0 0 {name=x1}
