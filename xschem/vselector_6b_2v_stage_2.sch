v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} 120 -260 0 0 {name=p5 lab=vin[0:4]}
C {devices/opin.sym} 100 -220 0 0 {name=p6 lab=vout[0:4]}
C {devices/title.sym} 160 -40 0 0 {name=l1 author="Yohanes Stefanus"}
C {devices/ipin.sym} 120 -200 0 0 {name=p8 lab=VNB}
C {devices/ipin.sym} 120 -240 0 0 {name=p12 lab=DIN}
C {devices/param.sym} 50 -360 0 0 {name=s1 value="
+wp=0.42
+wn=0.42
+l=0.5
"}
C {vselector_4b.sym} 470 -230 0 0 {name=x1}
C {vselector_4b.sym} 470 -300 0 0 {name=x2}
C {vselector_4b.sym} 470 -370 0 0 {name=x3}
