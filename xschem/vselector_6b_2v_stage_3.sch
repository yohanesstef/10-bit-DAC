v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} 120 -260 0 0 {name=p5 lab=vin[0:4]}
C {devices/opin.sym} 100 -220 0 0 {name=p6 lab=VH}
C {devices/title.sym} 160 -40 0 0 {name=l1 author="Yohanes Stefanus"}
C {devices/ipin.sym} 120 -180 0 0 {name=p8 lab=VNB}
C {devices/ipin.sym} 120 -240 0 0 {name=p12 lab=dec[0:3]}
C {devices/lab_pin.sym} 620 -460 0 1 {name=p1 sig_type=std_logic lab=VH}
C {devices/lab_pin.sym} 320 -250 0 0 {name=p2 sig_type=std_logic lab=vin[0:1]}
C {devices/lab_pin.sym} 320 -320 0 0 {name=p3 sig_type=std_logic lab=vin[1:2]}
C {devices/lab_pin.sym} 320 -390 0 0 {name=p4 sig_type=std_logic lab=vin[2:3]}
C {devices/lab_pin.sym} 320 -460 0 0 {name=p7 sig_type=std_logic lab=vin[3:4]}
C {devices/lab_pin.sym} 320 -420 0 0 {name=p14 sig_type=std_logic lab=VNB}
C {devices/lab_pin.sym} 320 -350 0 0 {name=p15 sig_type=std_logic lab=VNB}
C {devices/lab_pin.sym} 320 -280 0 0 {name=p16 sig_type=std_logic lab=VNB}
C {devices/lab_pin.sym} 320 -210 0 0 {name=p17 sig_type=std_logic lab=VNB}
C {devices/lab_pin.sym} 320 -440 0 0 {name=p18 sig_type=std_logic lab=dec[3]}
C {devices/lab_pin.sym} 320 -370 0 0 {name=p19 sig_type=std_logic lab=dec[2]}
C {devices/lab_pin.sym} 320 -300 0 0 {name=p20 sig_type=std_logic lab=dec[1]}
C {devices/lab_pin.sym} 320 -230 0 0 {name=p21 sig_type=std_logic lab=dec[0]}
C {vselector_1b.sym} 470 -230 0 0 {name=x1}
C {vselector_1b.sym} 470 -300 0 0 {name=x2}
C {vselector_1b.sym} 470 -370 0 0 {name=x3}
C {vselector_1b.sym} 470 -440 0 0 {name=x4}
C {devices/lab_pin.sym} 620 -440 0 1 {name=p9 sig_type=std_logic lab=VL}
C {devices/lab_pin.sym} 620 -390 0 1 {name=p10 sig_type=std_logic lab=VH}
C {devices/lab_pin.sym} 620 -370 0 1 {name=p11 sig_type=std_logic lab=VL}
C {devices/lab_pin.sym} 620 -320 0 1 {name=p13 sig_type=std_logic lab=VH}
C {devices/lab_pin.sym} 620 -300 0 1 {name=p22 sig_type=std_logic lab=VL}
C {devices/lab_pin.sym} 620 -250 0 1 {name=p23 sig_type=std_logic lab=VH}
C {devices/lab_pin.sym} 620 -230 0 1 {name=p24 sig_type=std_logic lab=VL}
C {devices/opin.sym} 100 -200 0 0 {name=p25 lab=VL}
